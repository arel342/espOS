/*
  ============================================================================
   espOS v1.6  -  "Mini HP" untuk ESP32-S3 + TFT ILI9341 2.8" (240x320, portrait)
   Dibuat oleh Farel
  ============================================================================
   FITUR
     - Boot animasi, layar utama (jam, tanggal, 6 aplikasi), tema Aurora/Senja/Mono
     - Tombol navigasi seperti HP:  [<] Kembali   [O] Beranda   [#] Aplikasi terbaru
     - Kalkulator  : + - x / % +/- C  (bisa dipakai penuh)
     - Catatan     : 4 catatan, keyboard QWERTY di layar, tersimpan di flash (LittleFS)
     - Berkas      : daftar file di flash, lihat isi, hapus, info penyimpanan
     - Stopwatch   : ikon stopwatch, langsung membuka stopwatch (Alat & Senter layar dihapus)
     - Setelan     : Tema, Atur jam & tanggal, KUNCI LAYAR (PIN 4-8 angka / pola), Info sistem, Kalibrasi touch,
                     Matikan layar, Tentang
     - Kalibrasi touch otomatis saat pertama kali menyala (disimpan permanen)
     - [BARU] Lock screen (jam & tanggal) - geser ke atas untuk membuka
     - [BARU] Control panel - geser dari atas ke bawah (juga bisa dari lock screen):
                Kecerahan, Wi-Fi, Senter (LED RGB bawaan), Kunci, Tidur (light sleep),
                Deep Sleep, pintasan Setelan
     - [BARU] Senter: ketuk 1x = putih, ketuk lagi = mati, tahan = pilih warna LED
     - [BARU] Wi-Fi + NTP zona WIB (Jakarta): jam, tanggal & tahun otomatis; ikon Wi-Fi
              hanya muncul saat terhubung
     - [BARU v1.3] Wi-Fi di control panel: ketuk = hidup/mati, TAHAN = buka Pengaturan Wi-Fi
              * daftar jaringan dipindai ulang otomatis tiap 2 detik
              * ketuk nama jaringan -> layar password + keyboard ala HP modern
                (baris angka, Shift / Caps Lock dengan ketuk 2x, ?123 + simbol, gelembung
                 huruf saat ditekan, hapus ditahan = hapus berulang, lihat/sembunyi password)
              * jaringan + password tersimpan di flash, tersambung otomatis saat boot
     - [BARU v1.6] BERANDA GESER ala HP: geser kiri/kanan untuk halaman aplikasi lain (titik halaman di bawah,
              ikut jari 1:1, lemparan cepat pindah halaman, tepi kenyal; tombol Beranda = kembali ke halaman 1)
     - [BARU v1.6] 3 GAME (halaman 2): Dino (mesin game mirip Chrome: lompat tahan = tinggi, tunduk, pterodaktil,
              siang/malam tiap 700 poin, HI score), Ping Pong (geser jari, lawan komputer, 7 poin),
              Flappy Bird (pipa, medali, skor terbaik). Skor terbaik tersimpan di flash.
     - [BARU v1.5] KUNCI LAYAR: Setelan > Kunci layar > PIN (4-8 angka) atau Pola (9 titik, min. 4).
              Disimpan sebagai hash (bukan teks asli); 5x salah = tunggu 30 detik; kecerahan tetap
              diatur dari slider control panel.
     - [BARU v1.4] ANIMASI HALUS (ESP32-S3 + TFT 2.8"):
              * transisi layar: buka aplikasi = zoom dari ikonnya, tutup = mengecil ke ikon,
                masuk/keluar sub-layar = geser + paralaks + bayangan, layar lain = pudar silang
              * control panel: pegas fisika, mengikuti jari 1:1, lemparan (fling) cepat didukung,
                tepi kenyal, pegangan bawah melebar saat "lepas = terbuka", bayangan lembut
              * lock screen: layar di baliknya muncul perlahan saat digeser, pegas buka/batal
              * detail sentuhan: ikon app mengecil+bercahaya+memantul, riak (ripple) di tombol,
                penanda aksen & panah bergeser di baris menu, lingkaran progres saat tile Wi-Fi/Senter
                ditahan (+ petunjuk teks), tombol navigasi berdenyut, cahaya di tepi atas saat ditarik
              * mesin gambar: kotak membulat ~5x lebih cepat, pengiriman frame ke TFT berjalan di core 0
                sambil core 1 menggambar frame berikutnya (pipeline)

  ---------------------------------------------------------------------------
   LIBRARY (Library Manager Arduino IDE):  Adafruit GFX Library, Adafruit ILI9341
   (LittleFS & Preferences sudah bawaan core ESP32. Touch XPT2046 dibaca langsung.)

   BOARD  : ESP32S3 Dev Module  (PSRAM boleh aktif / tidak)
            Partition Scheme: pakai yang default (harus ada partisi SPIFFS/LittleFS)
   Simpan file dalam satu folder  espOS_S3/ :
            espOS_S3.ino,  espos_types.h,  psram_heap.h,  games.h
   Disarankan Tools > PSRAM > "OPI PSRAM" (N16R8). Tanpa PSRAM animasi transisi otomatis dimatikan.

  ---------------------------------------------------------------------------
   PIN
     TFT   : CS=10  RESET=8  DC=9  MOSI=11  SCK=12  BL=6  MISO=13  VCC/GND
     TOUCH : T_CLK=12  T_CS=14  T_DIN=11  T_DO=13  T_IRQ=tidak dipakai
     LED   : LED RGB bawaan ESP32-S3 = GPIO48 (DevKitC-1 v1.1: GPIO38)  -> PIN_FLASH_LED
     WAKE  : tombol BOOT = GPIO0 (membangunkan dari deep sleep)         -> PIN_WAKE
  ============================================================================
*/

#include <Arduino.h>
#include <SPI.h>
#include <Adafruit_GFX.h>
#include <Adafruit_ILI9341.h>
#include <Preferences.h>
#include <LittleFS.h>
#include "esp_heap_caps.h"
#include <WiFi.h>
#include <time.h>
#include "esp_wifi.h"
#include "esp_sleep.h"
#include "driver/gpio.h"
#include "driver/rtc_io.h"
#include <math.h>
#include "espos_types.h"
#include "ota.h"
#include "psram_heap.h"       // Manajer PSRAM — simpan di folder yang sama

// ============================== PIN & KONFIGURASI ============================
#define PIN_TFT_CS    10
#define PIN_TFT_RST    8
#define PIN_TFT_DC     9
#define PIN_TFT_MOSI  11
#define PIN_TFT_SCK   12
#define PIN_TFT_BL     6
#define PIN_TFT_MISO  13
#define PIN_TS_CS     14

#define SCR_W 240
#define SCR_H 320
#define TFT_ROTATION   0      // 0 = portrait normal, 2 = dibalik 180 derajat
#define TFT_SPI_HZ     40000000UL   // TFT 2.8" ILI9341: 40 MHz aman. Kabel pendek? coba 60000000UL (lebih mulus)
#define TFT_INVERT     0            // 1 = balik warna (sebagian modul 2.8" IPS butuh ini)
#define UI_SMOOTH      1            // 1 = transisi & efek halus aktif, 0 = pindah layar langsung (hemat RAM)

// Nilai awal touch (dipakai bila belum dikalibrasi). Kalibrasi otomatis menimpanya.
#define TOUCH_X_MIN   250
#define TOUCH_X_MAX  3800
#define TOUCH_Y_MIN   250
#define TOUCH_Y_MAX  3850
#define TOUCH_SWAP_XY  0
#define TOUCH_Z_MIN  350
#define TOUCH_DEBUG    0      // 1 = cetak nilai raw touch ke Serial Monitor

#define USER_NAME     "Farel"
#define BATT_PERCENT  86

// ---- Wi-Fi & waktu (NTP) ----
#define WIFI_SSID   ""                 // (opsional) Wi-Fi bawaan; bisa juga diatur dari menu Wi-Fi
#define WIFI_PASS   ""                 // <-- ISI password Wi-Fi
#define NTP_TZ      "WIB-7"            // Jakarta = WIB = UTC+7 (tanpa DST)

// ---- LED senter, tombol bangun, sleep ----
#define PIN_FLASH_LED 48               // LED RGB bawaan ESP32-S3 (DevKitC-1 v1.1 = 38)
#define FLASH_LEVEL   255              // kecerahan senter 0..255 (LED WS2812 itu terang sekali)
#define PIN_WAKE        0              // tombol BOOT: bangun dari deep sleep (aktif LOW)
#define LONG_PRESS_MS 700              // lama tahan (ms) untuk tile Senter / Wi-Fi di control panel
#define FB_PREFER_PSRAM  1             // 1 = framebuffer utama di PSRAM (hemat ~150 KB RAM internal, sedikit lebih lambat). Perlu PSRAM aktif
#define BG_CACHE_INTERNAL 0            // 0 = bgBuf & snapBuf wajib di PSRAM (N16R8 punya 8 MB, lebih dari cukup)
#define SLEEP_LIGHT     1              // 1 = light sleep sungguhan (hemat daya), 0 = layar mati saja
static int clk_hh = 22, clk_mm = 8;      // jam awal
static int clk_wd = 4;                   // hari awal (0=Minggu ... 4=Kamis)
static int clk_dd = 22, clk_mo = 9;      // tanggal awal 22 Oktober (bulan 0-based)
static int clk_yy = 2026;                // tahun awal (otomatis dari NTP bila Wi-Fi terhubung)

// ============================== WARNA ========================================
constexpr u16 H(uint32_t c) { return ((c >> 8) & 0xF800) | ((c >> 5) & 0x07E0) | ((c >> 3) & 0x001F); }

static inline u16 mix(u16 fg, u16 bg, uint8_t a) {       // alpha blend RGB565
  if (a == 0) return bg;
  if (a == 255) return fg;
  uint32_t f = fg, b = bg;
  f = (f | (f << 16)) & 0x07E0F81FUL;
  b = (b | (b << 16)) & 0x07E0F81FUL;
  uint32_t al = ((uint32_t)a * 33) >> 8;
  uint32_t r = ((((f - b) * al) >> 5) + b) & 0x07E0F81FUL;
  return (u16)((r >> 16) | r);
}

static const u16 COL_WHITE  = H(0xF5F7FA);
static const u16 COL_TEXT   = H(0xF1F4F8);
static const u16 COL_MUTED  = H(0x9AA5B4);
static const u16 COL_MUTED2 = H(0x8B95A3);
static const u16 COL_LABEL  = H(0xC4CBD6);
static const u16 BOOT_BG    = H(0x02060D);

static const Theme THEMES[3] = {
  {"Aurora", H(0x050A13), H(0x0A1626), H(0x14C8AF), H(0x4B49E0), H(0x5FF0D6), H(0x6FF0D2), H(0x0F3A45), H(0x6DF0DA), 46, 38, 50},
  {"Senja",  H(0x13070A), H(0x25120F), H(0xFF7A45), H(0x9A3412), H(0xFFA070), H(0xFFB27A), H(0x5A2321), H(0xFF9D72), 40, 30, 50},
  {"Mono",   H(0x0A0B0E), H(0x15171B), H(0x9AA4B2), H(0x5A6270), H(0xB8C0CC), H(0xD3DAE3), H(0x2C3137), H(0xBFC6D0), 22, 18, 34},
};

// ============================== FONT & IKON (tertanam) =======================
// Font & ikon (biner) disimpan di FLASH (const) dan dibaca langsung - tidak memakan RAM.
alignas(4) static const uint8_t ASSET_BIN[] = {
0,0,0,0,36,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,2,1,36,0,0,255,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,1,0,5,5,76,0,0,251,14,0,5,5,77,0,0,251,27,0,5,5,78,0,0,251,
40,0,5,5,86,0,0,251,53,0,4,5,71,0,0,251,63,0,4,5,64,0,0,251,73,0,5,5,87,0,0,251,
86,0,5,5,84,0,0,251,99,0,2,5,33,0,0,251,104,0,3,6,33,0,255,251,113,0,5,5,74,0,0,251,
126,0,4,5,62,0,0,251,136,0,6,5,97,0,0,251,151,0,5,5,84,0,0,251,164,0,6,5,88,0,0,251,
179,0,4,5,68,0,0,251,189,0,6,6,88,0,0,251,207,0,5,5,78,0,0,251,220,0,5,5,71,0,0,251,
233,0,6,5,68,0,255,251,248,0,5,5,82,0,0,251,5,1,5,5,76,0,0,251,18,1,7,5,111,0,0,251,
36,1,5,5,77,0,0,251,49,1,6,5,68,0,255,251,64,1,5,5,77,0,0,251,88,4,225,0,150,96,26,10,
6,255,243,177,4,144,111,251,6,113,193,111,251,6,112,165,111,252,32,10,239,151,145,0,147,0,7,145,0,10,239,144,
111,236,54,113,92,103,0,198,113,92,111,236,48,111,254,103,0,111,253,103,0,111,255,111,250,103,0,111,247,103,0,103,
0,10,239,183,145,0,147,15,215,145,27,26,237,80,103,2,150,112,41,111,255,150,112,41,103,2,144,103,103,103,103,103,
6,112,103,6,112,103,8,102,210,103,43,54,139,32,110,96,6,122,80,103,10,80,103,0,103,0,103,0,103,0,111,253,
109,0,214,107,85,166,102,153,102,102,137,102,102,0,102,109,19,150,167,57,102,163,150,100,169,102,10,144,26,237,80,121,
19,208,147,0,162,121,19,208,26,237,80,111,249,103,45,111,249,103,0,103,0,26,237,80,121,19,208,147,0,162,121,19,
192,26,238,48,0,9,80,111,249,6,114,208,111,248,6,114,176,103,6,112,77,252,8,96,0,41,166,0,1,208,159,234,
0,15,255,245,0,72,0,0,72,0,0,72,0,0,72,0,117,3,151,80,57,117,3,133,145,135,11,236,16,177,3,150,
96,147,27,27,0,152,96,4,225,0,162,30,3,151,101,148,117,57,146,138,16,185,9,176,10,128,153,0,73,10,48,153,
112,3,225,0,165,144,133,8,80,10,32,177,2,168,80,0,106,0,0,72,0,0,72,0,175,255,80,2,80,1,96,1,
96,0,159,255,128,0,0,0,0,0,0,0,41,0,0,0,0,0,3,6,51,0,0,250,9,0,4,6,59,0,0,250,
21,0,7,7,107,0,0,249,46,0,5,7,82,0,0,250,64,0,8,6,122,0,0,250,88,0,6,6,100,0,0,250,
106,0,2,6,35,0,0,250,112,0,3,7,50,0,0,249,123,0,3,7,50,0,0,249,134,0,4,6,64,0,0,250,
146,0,7,5,107,0,0,251,164,0,3,2,41,0,0,255,167,0,3,3,46,0,0,253,172,0,3,1,41,0,0,255,
174,0,3,7,43,0,0,250,185,0,5,6,82,0,0,250,200,0,5,6,82,0,0,250,215,0,5,6,82,0,0,250,
230,0,5,6,82,0,0,250,245,0,5,6,82,0,0,250,4,1,5,6,82,0,0,250,19,1,5,6,82,0,0,250,
34,1,5,6,82,0,0,250,49,1,5,6,82,0,0,250,64,1,5,6,82,0,0,250,79,1,3,4,43,0,0,252,
85,1,3,5,43,0,0,252,93,1,7,5,107,0,0,251,111,1,7,4,107,0,0,252,125,1,7,5,107,0,0,251,
143,1,4,6,68,0,0,250,155,1,8,7,128,0,0,250,183,1,6,6,88,0,0,250,201,1,5,6,88,0,0,250,
216,1,6,6,90,0,0,250,234,1,6,6,98,0,0,250,252,1,5,6,81,0,0,250,11,2,5,6,74,0,0,250,
26,2,6,6,99,0,0,250,44,2,6,6,96,0,0,250,62,2,2,6,38,0,0,250,68,2,3,8,38,0,255,250,
80,2,6,6,84,0,0,250,98,2,5,6,71,0,0,250,113,2,7,6,110,0,0,250,134,2,6,6,96,0,0,250,
152,2,6,6,101,0,0,250,170,2,5,6,77,0,0,250,185,2,6,7,101,0,0,250,206,2,6,6,89,0,0,250,
224,2,5,6,81,0,0,250,239,2,6,6,78,0,255,250,1,3,6,6,94,0,0,250,19,3,6,6,88,0,0,250,
37,3,8,6,126,0,0,250,61,3,6,6,88,0,0,250,79,3,6,6,78,0,255,250,97,3,6,6,88,0,0,250,
115,3,3,7,50,0,0,250,126,3,3,7,43,0,0,250,137,3,3,7,50,0,0,250,148,3,7,6,107,0,0,250,
169,3,6,2,64,0,255,0,175,3,4,6,64,0,0,250,187,3,5,4,78,0,0,252,197,3,5,7,81,0,0,249,
215,3,4,4,70,0,0,252,223,3,5,7,81,0,0,249,241,3,5,4,79,0,0,252,251,3,3,7,45,0,0,249,
6,4,5,6,81,0,0,252,21,4,5,7,81,0,0,249,39,4,2,6,36,0,0,250,45,4,3,8,36,0,255,250,
57,4,5,7,74,0,0,249,75,4,2,7,36,0,0,249,82,4,8,4,125,0,0,252,98,4,5,4,81,0,0,252,
108,4,5,4,78,0,0,252,118,4,5,6,81,0,0,252,133,4,5,6,81,0,0,252,148,4,4,4,53,0,0,252,
156,4,4,4,67,0,0,252,164,4,3,5,50,0,0,251,172,4,5,4,81,0,0,252,182,4,5,4,76,0,0,252,
192,4,7,4,105,0,0,252,206,4,5,4,76,0,0,252,216,4,5,6,76,0,0,252,231,4,4,4,67,0,0,252,
239,4,5,7,82,0,0,250,1,5,3,8,43,0,0,250,13,5,5,7,82,0,0,250,31,5,7,4,107,0,0,252,
12,0,192,12,0,176,0,0,192,71,176,71,176,0,0,0,0,0,0,0,0,0,71,131,0,7,74,0,14,255,255,32,
10,41,0,127,255,250,0,86,131,0,8,58,0,0,0,112,2,207,242,89,112,1,156,145,0,121,102,239,194,0,112,0,
78,176,41,0,149,178,146,0,78,196,112,0,0,10,78,192,0,116,133,178,2,144,78,192,7,239,16,12,32,0,10,128,
0,88,122,57,121,23,226,27,236,106,71,71,0,0,0,0,7,80,176,74,5,128,74,0,176,7,80,57,0,161,7,96,
103,7,96,161,57,0,133,88,44,194,44,194,133,104,0,0,0,0,0,11,0,0,0,176,0,63,255,253,0,0,176,0,
0,11,0,0,44,5,96,175,128,0,0,0,59,0,2,144,117,10,17,160,87,9,32,176,0,10,235,21,177,166,118,5,
151,96,88,91,26,96,174,177,63,241,0,11,16,0,177,0,11,16,0,177,0,255,246,127,250,0,1,180,0,11,16,26,
48,43,48,7,255,245,79,250,0,1,181,0,27,48,127,177,0,26,119,255,194,0,140,0,40,192,9,28,4,96,192,175,
255,160,0,192,63,255,3,160,0,62,234,0,1,165,0,26,87,254,160,7,239,67,227,0,105,0,7,190,212,75,40,144,
158,211,111,255,96,0,177,0,58,0,9,64,1,192,0,104,0,11,236,21,177,166,59,26,81,191,193,121,40,131,223,212,
44,234,8,146,165,61,234,128,0,136,0,61,67,254,128,28,0,0,0,1,192,28,0,0,0,2,192,86,0,0,4,153,
1,154,131,0,25,168,48,0,0,73,144,0,0,0,0,63,255,253,0,0,0,0,63,255,253,0,0,0,0,43,114,0,
0,4,154,112,0,73,167,2,183,32,0,0,0,0,0,127,230,0,105,3,177,7,96,0,0,8,96,1,158,235,48,11,
114,21,193,86,94,185,70,131,164,75,134,103,94,189,160,11,114,41,32,1,174,212,0,0,214,0,5,155,0,10,59,32,
28,6,128,127,255,208,195,0,180,79,253,68,144,106,73,6,148,255,245,73,3,212,255,232,6,222,144,77,50,131,134,0,
0,134,0,0,77,49,131,6,222,144,79,253,128,73,3,198,73,0,74,73,0,74,73,3,198,79,253,128,79,255,132,144,
0,73,0,4,255,246,73,0,4,255,249,79,255,52,144,0,73,0,4,255,224,73,0,4,144,0,6,222,161,77,49,102,
134,9,249,134,0,73,77,49,105,7,222,178,73,0,148,73,0,148,73,0,148,79,255,244,73,0,148,73,0,148,73,73,
73,73,73,73,4,144,73,4,144,73,4,144,73,7,135,211,73,6,161,73,106,0,77,160,0,75,194,0,73,60,32,73,
3,194,73,0,4,144,0,73,0,4,144,0,73,0,4,255,247,79,48,79,52,200,9,195,73,176,170,52,152,135,163,73,
62,26,52,144,0,163,79,48,148,76,160,148,73,179,148,73,58,148,73,10,196,73,3,244,7,222,161,77,50,168,134,0,
44,134,0,44,77,49,168,7,222,161,79,253,52,145,152,79,253,52,144,0,73,0,4,144,0,7,222,161,77,50,168,134,
0,44,134,0,44,77,49,168,7,223,160,0,3,193,79,253,64,73,8,128,79,253,32,73,27,80,73,3,176,73,0,179,
44,255,87,145,0,76,132,0,38,182,0,7,168,255,211,31,255,254,0,12,0,0,12,0,0,12,0,0,12,0,0,12,
0,88,0,163,88,0,163,88,0,163,88,0,163,60,35,209,8,238,96,194,0,164,119,1,192,28,6,128,10,59,32,5,
171,0,0,214,0,163,10,144,89,103,10,160,149,59,41,161,193,12,102,117,192,10,178,59,144,7,208,14,96,74,3,176,
9,107,48,1,216,0,3,202,0,11,58,80,119,1,193,11,48,89,2,193,193,0,125,80,0,13,0,0,12,0,0,12,
0,159,255,224,0,6,80,0,71,0,3,128,0,25,0,0,159,255,243,111,102,112,103,6,112,103,6,112,111,96,176,9,
32,87,1,160,10,16,117,2,144,79,112,87,5,112,87,5,112,87,79,112,0,156,80,0,149,8,96,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,47,255,242,24,48,0,0,0,0,0,0,0,0,0,0,79,251,3,223,243,
135,44,52,237,179,88,0,5,128,0,88,0,5,174,211,91,22,149,177,105,90,237,48,43,254,136,16,136,16,43,254,0,
6,96,0,102,0,6,98,206,166,135,26,104,113,166,44,234,96,27,253,56,255,248,136,16,1,191,246,10,225,176,42,13,
252,58,3,160,58,0,44,234,104,113,166,135,26,98,206,166,0,27,49,254,144,88,0,5,128,0,88,0,5,174,210,91,
25,101,128,103,88,6,112,88,0,88,88,88,88,5,128,0,5,128,88,5,128,88,6,115,227,88,0,5,128,0,88,0,
5,131,162,91,161,5,171,32,88,43,48,88,88,88,88,88,88,88,91,236,126,160,91,26,129,193,88,7,80,162,88,7,
80,162,90,237,37,177,150,88,6,117,128,103,44,235,24,129,150,136,25,98,206,177,90,237,53,177,105,91,22,149,174,211,
88,0,5,128,0,44,234,104,113,166,135,26,98,206,166,0,6,96,0,102,90,213,91,16,88,0,88,0,94,249,121,48,
3,122,159,231,88,12,254,88,4,144,45,224,103,7,102,112,118,90,26,97,206,166,148,8,83,160,192,11,104,0,110,32,
148,93,10,36,137,147,176,11,164,168,0,168,14,64,74,27,32,125,64,9,181,6,129,179,148,8,82,161,192,10,135,0,
78,16,5,144,6,227,0,159,252,0,65,5,16,159,253,0,143,32,11,16,1,192,0,249,0,1,192,0,11,16,0,143,
32,11,0,176,11,0,176,11,0,176,11,0,176,15,144,0,28,0,0,193,0,9,242,0,194,0,28,0,15,144,0,0,
0,0,0,174,130,128,36,42,231,0,0,0,0,0,0,0,0,0,0,0,46,0,0,0,0,0,4,7,58,0,0,249,
14,0,4,7,66,0,0,249,28,0,8,7,121,0,0,249,56,0,6,8,92,0,0,249,80,0,9,7,137,0,0,249,
112,0,7,7,112,0,0,249,137,0,2,7,40,0,0,249,144,0,4,8,56,0,0,248,160,0,4,8,56,0,0,248,
176,0,5,7,72,0,0,249,194,0,8,5,121,0,0,251,214,0,3,2,46,0,0,255,217,0,3,3,52,0,0,253,
222,0,3,1,46,0,0,255,224,0,4,7,48,0,0,249,238,0,6,7,92,0,0,249,3,1,6,7,92,0,0,249,
24,1,6,7,92,0,0,249,45,1,6,7,92,0,0,249,66,1,6,7,92,0,0,249,87,1,6,7,92,0,0,249,
108,1,6,7,92,0,0,249,129,1,6,7,92,0,0,249,150,1,6,7,92,0,0,249,171,1,6,7,92,0,0,249,
192,1,3,5,48,0,0,251,200,1,3,6,48,0,0,251,209,1,8,5,121,0,0,251,229,1,8,4,121,0,0,252,
245,1,8,5,121,0,0,251,9,2,5,7,76,0,0,249,27,2,9,8,144,0,0,250,63,2,7,7,98,0,0,249,
88,2,6,7,99,0,0,249,109,2,6,7,100,0,0,249,130,2,7,7,111,0,0,249,155,2,6,7,91,0,0,249,
176,2,5,7,83,0,0,249,194,2,7,7,112,0,0,249,219,2,7,7,108,0,0,249,244,2,3,7,42,0,0,249,
255,2,4,9,42,0,255,249,17,3,7,7,94,0,0,249,42,3,5,7,80,0,0,249,60,3,8,7,124,0,0,249,
88,3,7,7,108,0,0,249,113,3,7,7,113,0,0,249,138,3,6,7,87,0,0,249,159,3,7,8,113,0,0,249,
187,3,6,7,100,0,0,249,208,3,6,7,92,0,0,249,229,3,7,7,88,0,255,249,254,3,7,7,106,0,0,249,
23,4,7,7,98,0,0,249,48,4,9,7,142,0,0,249,80,4,6,7,99,0,0,249,101,4,7,7,88,0,255,249,
126,4,6,7,99,0,0,249,147,4,4,8,56,0,0,249,163,4,4,7,48,0,0,249,177,4,4,8,56,0,0,249,
193,4,8,7,121,0,0,249,221,4,6,2,72,0,255,0,227,4,5,7,72,0,0,249,245,4,6,5,88,0,0,251,
4,5,6,8,92,0,0,248,28,5,5,5,79,0,0,251,41,5,6,8,92,0,0,248,65,5,6,5,88,0,0,251,
80,5,4,8,51,0,0,248,96,5,6,7,92,0,0,251,117,5,6,8,91,0,0,248,141,5,3,7,40,0,0,249,
152,5,4,9,40,0,255,249,170,5,6,8,84,0,0,248,194,5,3,8,40,0,0,248,206,5,9,5,140,0,0,251,
229,5,6,5,91,0,0,251,244,5,6,5,88,0,0,251,3,6,6,7,92,0,0,251,24,6,6,7,92,0,0,251,
45,6,4,5,59,0,0,251,55,6,5,5,75,0,0,251,68,6,4,6,56,0,0,250,80,6,6,5,91,0,0,251,
95,6,6,5,85,0,0,251,110,6,7,5,118,0,0,251,128,6,6,5,85,0,0,251,143,6,6,7,85,0,0,251,
164,6,5,5,76,0,0,251,177,6,6,8,92,0,0,249,201,6,3,9,48,0,0,249,215,6,6,8,92,0,0,249,
239,6,8,5,121,0,0,251,10,80,10,80,10,80,10,64,9,48,0,0,10,80,58,133,58,133,0,0,0,0,0,0,
0,0,0,0,0,11,11,0,0,42,42,0,12,255,255,208,0,147,163,0,111,255,255,96,1,161,160,0,5,117,112,0,
0,113,0,10,255,144,75,129,0,45,181,0,2,170,176,0,115,208,95,254,112,0,113,0,45,210,6,112,7,118,129,176,
0,119,104,132,0,2,221,74,142,128,0,10,44,28,0,5,128,193,192,0,177,8,233,0,4,221,48,0,166,55,0,8,
160,0,2,182,160,134,120,7,187,21,211,44,176,9,238,123,96,58,58,0,0,0,0,0,4,144,11,32,28,0,59,0,
59,0,28,0,11,32,4,144,42,0,10,64,6,144,3,176,3,176,6,144,10,64,42,0,131,137,33,173,80,26,213,8,
56,146,0,0,0,0,0,0,0,0,0,10,48,0,0,10,48,0,31,255,255,160,0,10,48,0,0,10,48,0,14,3,
144,159,208,0,0,0,30,0,0,192,4,144,9,64,12,0,73,0,148,0,192,0,7,237,64,45,53,192,106,0,209,120,
0,194,106,0,209,45,53,192,7,237,64,15,248,0,0,120,0,0,120,0,0,120,0,0,120,0,0,120,0,14,255,224,
25,237,64,87,23,176,0,4,176,0,28,48,1,180,0,28,80,0,111,255,208,8,237,64,40,21,192,0,5,176,4,254,
64,0,4,208,86,20,208,26,237,80,0,63,80,0,171,80,4,154,80,11,26,80,87,10,80,159,255,244,0,10,80,31,
255,128,28,0,0,28,0,0,31,253,64,0,5,208,0,5,208,111,253,80,4,207,192,30,96,0,92,0,0,107,222,112,
93,34,210,29,34,209,6,238,112,95,255,224,0,5,144,0,11,64,0,45,0,0,120,0,0,195,0,3,192,0,9,238,
96,61,36,208,44,36,192,9,255,80,91,19,209,107,19,225,26,238,112,10,237,48,107,20,176,107,20,240,27,235,209,0,
2,224,0,26,160,15,235,32,14,0,0,0,0,0,14,0,14,0,0,0,0,0,14,3,144,0,0,74,128,2,140,164,
0,31,177,0,0,2,140,164,0,0,0,74,128,31,255,255,160,0,0,0,0,31,255,255,160,0,0,0,0,28,114,0,
0,1,124,181,0,0,0,94,144,1,124,181,0,28,114,0,0,111,250,0,2,210,0,122,0,44,0,5,144,0,0,0,
5,160,0,0,125,253,129,0,139,65,41,176,43,11,234,121,70,85,145,151,102,102,89,25,123,51,177,190,173,96,9,180,
20,144,0,7,223,177,0,0,172,0,0,29,194,0,6,168,128,0,182,61,0,30,16,212,7,255,255,144,197,0,61,0,
47,254,160,44,2,196,44,2,195,47,255,176,44,1,167,44,1,168,47,255,178,3,206,212,30,97,57,106,0,0,136,0,
0,106,0,0,30,97,57,4,206,212,47,254,179,2,192,39,209,44,0,11,82,192,0,150,44,0,11,82,192,39,209,47,
254,179,0,47,255,241,44,0,0,44,0,0,47,255,224,44,0,0,44,0,0,47,255,242,47,255,178,192,0,44,0,2,
255,247,44,0,2,192,0,44,0,0,4,206,215,1,230,19,161,106,0,0,8,128,47,244,106,0,10,65,230,18,180,4,
206,216,0,44,0,14,2,192,0,224,44,0,14,2,255,255,224,44,0,14,2,192,0,224,44,0,14,0,44,2,192,44,
2,192,44,2,192,44,0,2,192,2,192,2,192,2,192,2,192,2,192,3,192,6,160,141,64,44,1,198,2,193,199,0,
44,199,0,2,237,16,0,44,124,16,2,192,139,0,44,0,154,0,44,0,2,192,0,44,0,2,192,0,44,0,2,192,
0,47,255,240,47,96,10,224,45,176,12,208,44,177,88,208,44,118,163,208,44,43,192,208,44,11,128,208,44,0,0,208,
47,96,13,2,220,0,208,44,150,13,2,194,192,208,44,10,109,2,192,44,208,44,0,173,0,4,206,197,1,230,21,226,
106,0,9,120,128,0,121,106,0,9,113,230,21,226,4,206,213,0,47,254,112,44,3,225,44,3,225,47,254,128,44,0,
0,44,0,0,44,0,0,4,206,213,1,230,21,226,106,0,9,120,128,0,121,106,0,9,113,230,21,210,4,207,244,0,
0,10,144,47,254,128,44,3,225,44,3,225,47,255,112,44,5,192,44,0,165,44,0,76,10,237,80,108,35,144,91,0,
0,7,170,80,0,1,210,103,19,227,26,238,128,31,255,255,144,0,180,0,0,11,64,0,0,180,0,0,11,64,0,0,
180,0,0,11,64,0,75,0,45,4,176,2,208,75,0,45,4,176,2,208,59,0,60,1,228,25,144,5,222,178,0,195,
0,29,7,144,7,144,29,0,180,0,180,45,0,6,167,128,0,29,194,0,0,172,0,0,166,3,242,7,134,144,124,80,
165,44,10,89,13,16,209,176,178,192,10,106,11,105,0,124,112,140,80,3,243,5,242,0,60,0,151,8,132,192,1,204,
48,0,156,0,3,202,96,12,66,209,121,0,121,11,80,12,64,44,23,144,0,138,209,0,0,214,0,0,11,64,0,0,
180,0,0,11,64,0,143,255,250,0,1,178,0,10,80,0,120,0,4,176,0,44,16,0,159,255,252,79,160,73,0,73,
0,73,0,73,0,73,0,73,0,79,160,192,0,148,0,73,0,12,0,9,64,4,144,0,192,63,192,2,192,2,192,2,
192,2,192,2,192,2,192,63,192,0,92,177,0,8,128,59,48,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,47,255,250,28,16,0,73,0,0,0,0,0,0,0,0,0,0,0,0,0,0,47,252,32,
0,6,144,44,255,176,121,22,176,61,233,176,74,0,0,74,0,0,74,0,0,75,206,112,78,51,209,75,0,180,78,51,
209,75,206,112,9,239,117,178,0,135,0,5,178,0,9,239,112,0,0,192,0,0,192,0,0,192,10,234,192,107,22,224,
134,0,208,107,21,224,10,234,192,9,237,80,90,19,208,143,255,241,90,32,0,9,239,208,8,246,13,16,12,0,207,243,
12,0,12,0,12,0,12,0,10,234,192,107,21,224,134,0,208,107,21,224,10,234,192,0,6,176,14,252,48,74,0,0,
74,0,0,74,0,0,75,206,96,77,51,208,74,0,208,74,0,208,74,0,208,59,0,0,59,3,176,59,3,176,59,0,
3,176,0,0,3,176,3,176,3,176,3,176,3,160,5,160,62,64,74,0,0,74,0,0,74,0,0,74,8,144,74,167,
0,78,192,0,74,122,0,74,7,160,59,3,176,59,3,176,59,3,176,59,3,176,75,206,107,231,4,210,78,66,208,74,
0,208,13,4,160,13,0,208,74,0,208,13,0,75,206,96,77,51,208,74,0,208,74,0,208,74,0,208,10,237,64,107,
21,208,135,0,208,107,21,208,10,237,64,75,206,112,78,51,209,75,0,180,78,51,209,75,206,112,74,0,0,74,0,0,
10,234,192,107,22,224,134,0,208,107,21,224,10,234,192,0,0,192,0,0,192,75,203,78,48,74,0,74,0,74,0,61,
255,7,128,0,42,200,0,1,196,159,251,16,58,0,207,246,58,0,58,0,59,0,12,246,73,0,208,73,0,208,73,0,
208,60,21,224,10,233,208,149,1,208,59,6,128,12,27,48,8,140,0,2,247,0,134,14,80,196,148,185,74,28,117,184,
96,188,26,194,8,192,125,0,75,7,144,8,172,16,1,230,0,10,124,16,105,5,176,150,1,192,59,7,128,11,44,32,
5,186,0,0,228,0,3,192,0,94,80,0,143,255,80,3,128,2,144,1,145,0,159,255,96,0,78,160,0,135,0,0,
165,0,13,209,0,1,181,0,0,150,0,0,135,0,0,77,160,12,0,192,12,0,192,12,0,192,12,0,192,12,0,13,
193,0,0,164,0,0,151,0,0,79,160,0,152,0,0,149,0,0,180,0,13,193,0,0,0,0,0,8,235,51,128,22,
23,237,48,0,0,0,0,0,0,0,0,0,0,0,0,0,51,0,0,0,0,0,4,7,64,0,0,249,14,0,5,7,
74,0,0,249,32,0,8,7,134,0,0,249,60,0,6,8,102,0,0,249,84,0,10,7,152,0,0,249,119,0,8,7,
125,0,0,249,147,0,3,7,44,0,0,249,158,0,4,9,62,0,0,248,176,0,4,9,62,0,0,248,194,0,5,7,
80,0,0,249,212,0,8,7,134,0,0,249,240,0,3,2,51,0,0,255,243,0,4,3,58,0,0,253,249,0,3,1,
51,0,0,255,251,0,4,8,54,0,0,249,11,1,6,7,102,0,0,249,32,1,6,7,102,0,0,249,53,1,6,7,
102,0,0,249,74,1,6,7,102,0,0,249,95,1,6,7,102,0,0,249,116,1,6,7,102,0,0,249,137,1,6,7,
102,0,0,249,158,1,6,7,102,0,0,249,179,1,6,7,102,0,0,249,200,1,6,7,102,0,0,249,221,1,3,5,
54,0,0,251,229,1,3,6,54,0,0,251,238,1,8,6,134,0,0,250,6,2,8,5,134,0,0,251,26,2,8,6,
134,0,0,250,50,2,5,7,85,0,0,249,68,2,10,9,160,0,0,249,113,2,7,7,110,0,0,249,138,2,7,7,
110,0,0,249,163,2,7,7,112,0,0,249,188,2,8,7,123,0,0,249,216,2,6,7,101,0,0,249,237,2,6,7,
92,0,0,249,2,3,8,7,124,0,0,249,30,3,8,7,120,0,0,249,58,3,3,7,47,0,0,249,69,3,4,9,
47,0,255,249,87,3,7,7,105,0,0,249,112,3,6,7,89,0,0,249,133,3,9,7,138,0,0,249,165,3,7,7,
120,0,0,249,190,3,8,7,126,0,0,249,218,3,6,7,96,0,0,249,239,3,8,8,126,0,0,249,15,4,7,7,
111,0,0,249,40,4,6,7,102,0,0,249,61,4,8,7,98,0,255,249,89,4,7,7,117,0,0,249,114,4,7,7,
110,0,0,249,139,4,10,7,158,0,0,249,174,4,7,7,110,0,0,249,199,4,8,7,98,0,255,249,227,4,7,7,
110,0,0,249,252,4,4,9,62,0,0,248,14,5,4,8,54,0,0,249,30,5,4,9,62,0,0,248,48,5,8,7,
134,0,0,249,76,5,7,2,80,0,255,0,83,5,5,8,80,0,0,248,103,5,6,5,98,0,0,251,118,5,6,8,
102,0,0,248,142,5,6,5,88,0,0,251,157,5,6,8,102,0,0,248,181,5,6,5,98,0,0,251,196,5,4,8,
56,0,0,248,212,5,6,7,102,0,0,251,233,5,6,8,102,0,0,248,1,6,3,8,44,0,0,248,13,6,4,10,
44,0,255,248,33,6,6,8,93,0,0,248,57,6,3,8,44,0,0,248,69,6,10,5,156,0,0,251,94,6,6,5,
102,0,0,251,109,6,6,5,98,0,0,251,124,6,6,7,102,0,0,251,145,6,6,7,102,0,0,251,166,6,5,5,
66,0,0,251,179,6,5,5,83,0,0,251,192,6,4,7,63,0,0,249,206,6,6,5,102,0,0,251,221,6,6,5,
95,0,0,251,236,6,8,5,131,0,0,251,0,7,6,5,95,0,0,251,15,7,6,7,95,0,0,251,36,7,5,5,
84,0,0,251,49,7,6,9,102,0,0,248,76,7,3,10,54,0,0,248,91,7,6,9,102,0,0,248,118,7,8,5,
134,0,0,251,8,128,8,128,8,128,8,128,7,112,0,0,8,128,28,74,1,196,160,28,74,0,0,0,0,0,0,0,
0,0,0,0,0,9,86,128,0,12,25,64,11,255,255,250,0,88,43,0,79,255,255,241,0,192,163,0,2,176,192,0,
0,39,0,8,239,242,45,71,0,29,169,32,1,107,212,0,39,152,63,239,178,0,39,0,28,230,0,163,0,121,45,6,
128,0,121,45,43,0,0,28,230,164,206,112,0,5,134,146,208,0,27,22,146,208,0,164,1,206,112,3,206,128,0,8,
161,129,0,5,194,0,0,27,92,48,209,106,2,200,160,78,65,127,96,7,223,180,211,28,1,192,28,0,0,0,0,0,
0,0,1,192,8,112,13,32,30,0,61,0,30,0,13,32,8,112,1,192,28,0,8,96,4,176,0,224,0,225,0,224,
3,176,8,96,28,0,133,149,129,157,145,25,217,24,89,88,0,0,0,0,0,0,0,0,0,4,160,0,0,4,160,0,
0,4,160,0,14,255,255,246,0,4,160,0,0,4,160,0,0,4,160,0,13,50,176,159,243,0,0,0,0,14,32,0,
164,0,208,5,144,9,80,13,0,74,0,149,0,193,0,5,222,144,30,82,198,76,0,122,107,0,91,76,0,122,30,82,
198,5,222,144,14,253,0,0,61,0,0,61,0,0,61,0,0,61,0,0,61,0,12,255,247,8,238,144,72,35,228,0,
0,195,0,8,144,0,153,0,27,128,0,95,255,246,6,222,144,10,34,213,0,2,196,0,255,160,0,2,183,71,18,184,
25,238,161,0,28,192,0,151,192,6,116,192,42,4,192,143,255,252,0,4,192,0,4,192,14,255,224,14,0,0,14,238,
128,0,3,213,0,0,151,0,3,213,79,254,128,2,190,245,12,161,0,62,16,0,92,191,195,78,65,154,13,65,154,4,
222,194,63,255,248,0,0,210,0,5,176,0,11,80,0,61,0,0,152,0,1,226,0,7,238,177,46,49,183,29,49,182,
7,255,176,61,33,152,77,33,153,9,238,194,9,238,128,93,34,181,93,34,185,9,238,170,0,0,168,0,5,227,14,253,
80,13,64,0,0,0,0,13,64,13,64,0,0,0,0,13,50,176,0,0,23,181,1,107,199,32,14,212,0,0,1,107,
199,32,0,0,39,181,0,0,0,0,14,255,255,246,0,0,0,0,14,255,255,246,0,0,0,0,0,0,0,0,12,131,
0,0,1,90,200,48,0,0,26,245,1,90,200,48,12,147,0,0,0,0,0,0,95,253,64,1,153,0,77,48,13,48,
1,208,0,0,0,2,224,0,0,59,239,198,0,4,214,33,76,128,12,32,0,0,178,73,9,236,178,133,102,13,50,212,
194,73,9,236,188,80,13,48,0,0,0,5,214,34,121,0,0,75,238,180,0,0,111,48,0,12,137,0,3,176,193,0,
149,8,96,30,255,252,6,160,0,195,181,0,7,144,15,255,212,0,240,7,192,15,0,123,0,255,254,80,15,0,78,16,
240,4,242,15,255,231,0,2,174,234,17,217,34,102,92,0,0,7,160,0,0,92,0,0,1,217,34,102,2,174,234,16,
15,255,217,16,15,1,76,144,15,0,3,224,15,0,0,242,15,0,3,224,15,1,76,144,15,255,217,16,15,255,250,15,
0,0,15,0,0,15,255,247,15,0,0,15,0,0,15,255,251,15,255,243,15,0,0,15,0,0,15,255,208,15,0,0,
15,0,0,15,0,0,2,174,235,48,29,146,21,144,92,0,0,0,122,0,191,224,92,0,1,224,29,146,20,224,2,174,
236,80,15,0,8,144,15,0,8,144,15,0,8,144,15,255,255,144,15,0,8,144,15,0,8,144,15,0,8,144,15,0,
240,15,0,240,15,0,240,15,0,0,240,0,240,0,240,0,240,0,240,0,240,1,224,5,208,158,80,15,0,109,32,240,
124,32,15,155,16,0,254,64,0,15,77,64,0,240,61,80,15,0,61,80,15,0,0,15,0,0,15,0,0,15,0,0,
15,0,0,15,0,0,15,255,249,15,160,1,235,0,236,16,108,176,14,134,12,123,0,226,194,182,176,14,12,166,107,0,
224,110,22,176,14,0,0,107,0,15,160,8,128,237,48,136,14,107,8,128,224,197,136,14,4,200,128,224,11,200,14,0,
63,128,2,190,234,32,29,146,42,176,93,0,1,227,122,0,0,197,93,0,1,227,29,146,42,176,2,190,234,32,15,254,
194,15,1,170,15,1,170,15,255,195,15,0,0,15,0,0,15,0,0,2,190,234,32,29,146,42,192,93,0,1,227,122,
0,0,197,93,0,1,227,29,146,42,176,2,190,251,16,0,0,77,64,15,255,195,0,240,26,160,15,1,169,0,255,253,
16,15,2,198,0,240,3,208,15,0,11,112,9,238,145,93,49,118,76,16,0,5,170,145,0,0,122,88,33,155,24,238,
195,31,255,255,243,0,7,144,0,0,7,144,0,0,7,144,0,0,7,144,0,0,7,144,0,0,7,144,0,61,0,9,
131,208,0,152,61,0,9,131,208,0,152,46,0,10,112,215,20,227,4,206,215,0,181,0,8,150,176,0,211,30,32,92,
0,152,10,96,3,210,225,0,12,185,0,0,111,48,0,152,0,202,0,151,91,1,204,0,211,30,21,154,50,224,12,73,
87,118,160,8,140,19,186,112,4,204,0,221,48,1,233,0,173,0,45,32,45,32,107,12,80,0,172,144,0,5,243,0,
1,215,192,0,167,9,128,107,0,29,64,11,112,5,192,2,211,45,48,0,92,182,0,0,10,176,0,0,7,144,0,0,
7,144,0,0,7,144,0,127,255,255,80,0,6,160,0,5,176,0,3,193,0,2,194,0,1,195,0,0,143,255,255,112,
63,224,60,0,60,0,60,0,60,0,60,0,60,0,60,0,63,224,193,0,149,0,74,0,13,0,9,80,5,144,0,208,
0,164,31,241,0,209,0,209,0,209,0,209,0,209,0,209,0,209,31,241,0,11,227,0,0,169,77,32,8,144,4,193,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,2,255,255,242,11,48,0,43,16,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,15,254,112,0,2,210,43,239,244,107,35,212,44,235,196,45,0,0,45,0,0,
45,0,0,45,174,194,47,81,154,45,0,60,47,81,154,45,174,194,7,223,208,77,48,0,121,0,0,77,48,0,7,239,
208,0,0,135,0,0,135,0,0,135,9,237,167,93,34,215,121,0,135,93,34,199,9,237,167,7,222,161,76,33,152,127,
255,250,76,48,0,7,223,247,6,235,12,48,14,0,207,248,14,0,14,0,14,0,14,0,9,237,167,93,34,199,121,0,
135,93,34,199,9,237,167,0,3,212,12,254,128,45,0,0,45,0,0,45,0,0,45,174,193,47,81,167,45,0,120,45,
0,120,45,0,120,29,0,0,0,1,208,29,1,208,29,1,208,1,208,0,0,0,0,1,208,1,208,1,208,1,208,1,
208,4,192,78,96,45,0,0,45,0,0,45,0,0,45,4,195,45,123,16,46,226,0,45,76,48,45,3,197,29,1,208,
29,1,208,29,1,208,29,1,208,45,174,181,238,80,47,65,203,37,192,45,0,150,0,224,45,0,150,0,224,45,0,150,
0,224,45,174,193,47,81,167,45,0,120,45,0,120,45,0,120,8,238,144,77,50,198,121,0,121,93,50,198,8,238,160,
45,174,194,47,81,154,45,0,60,47,81,154,45,174,194,45,0,0,45,0,0,9,237,167,93,34,215,121,0,135,93,34,
199,9,237,167,0,0,135,0,0,135,45,174,34,245,0,45,0,2,208,0,45,0,0,44,255,118,161,0,26,202,48,0,
123,143,253,80,45,0,45,0,207,251,45,0,45,0,30,16,10,251,60,0,135,60,0,135,60,0,135,46,34,199,8,236,
167,136,0,151,45,1,209,11,86,160,5,188,48,0,220,0,120,10,192,90,60,12,194,150,13,74,134,209,10,198,60,192,
5,241,13,128,61,34,211,6,204,80,0,203,0,8,155,112,107,1,196,136,0,151,45,1,209,9,103,128,3,205,32,0,
185,0,1,195,0,79,144,0,143,255,192,1,146,1,146,1,146,0,159,255,208,0,28,242,0,76,16,0,75,0,0,122,
0,12,244,0,0,138,0,0,91,0,0,76,16,0,28,242,12,32,194,12,32,194,12,32,194,12,32,194,12,32,194,12,
212,0,0,137,0,0,106,0,0,92,16,0,12,242,0,93,16,0,106,0,0,121,0,12,212,0,0,0,0,0,7,237,
113,117,7,36,190,161,0,0,0,0,0,0,0,0,0,0,0,0,0,0,50,0,0,0,0,0,4,7,66,0,0,249,
14,0,5,7,75,0,0,249,32,0,8,7,121,0,0,249,60,0,6,8,100,0,0,249,84,0,9,7,144,0,0,249,
116,0,8,7,126,0,0,249,144,0,3,7,44,0,0,249,155,0,4,8,66,0,0,248,171,0,4,8,66,0,0,248,
187,0,5,7,75,0,0,249,205,0,8,5,121,0,0,251,225,0,3,3,55,0,0,254,230,0,4,3,60,0,0,253,
236,0,3,2,55,0,0,254,239,0,4,7,52,0,0,249,253,0,6,7,100,0,0,249,18,1,6,7,100,0,0,249,
39,1,6,7,100,0,0,249,60,1,6,7,100,0,0,249,81,1,6,7,100,0,0,249,102,1,6,7,100,0,0,249,
123,1,6,7,100,0,0,249,144,1,6,7,100,0,0,249,165,1,6,7,100,0,0,249,186,1,6,7,100,0,0,249,
207,1,4,5,58,0,0,251,217,1,4,6,58,0,0,251,229,1,8,5,121,0,0,251,249,1,8,4,121,0,0,252,
9,2,8,5,121,0,0,251,29,2,5,7,84,0,0,249,47,2,9,8,144,0,0,249,83,2,7,7,112,0,0,249,
108,2,7,7,110,0,0,249,133,2,7,7,106,0,0,249,158,2,7,7,120,0,0,249,183,2,6,7,98,0,0,249,
204,2,6,7,98,0,0,249,225,2,7,7,118,0,0,249,250,2,8,7,120,0,0,249,22,3,3,7,54,0,0,249,
33,3,4,9,54,0,255,249,51,3,8,7,112,0,0,249,79,3,6,7,92,0,0,249,100,3,9,7,143,0,0,249,
132,3,8,7,120,0,0,249,160,3,8,7,122,0,0,249,188,3,7,7,106,0,0,249,213,3,8,8,122,0,0,249,
245,3,7,7,111,0,0,249,14,4,6,7,104,0,0,249,35,4,7,7,98,0,0,249,60,4,7,7,117,0,0,249,
85,4,7,7,112,0,0,249,110,4,10,7,159,0,0,249,145,4,7,7,111,0,0,249,170,4,8,7,104,0,255,249,
198,4,7,7,104,0,0,249,223,4,4,8,66,0,0,248,239,4,4,7,52,0,0,249,253,4,4,8,66,0,0,248,
13,5,8,7,121,0,0,249,41,5,5,2,72,0,0,0,46,5,5,7,72,0,0,249,64,5,6,5,97,0,0,251,
79,5,7,8,103,0,0,248,107,5,5,5,85,0,0,251,120,5,6,8,103,0,0,248,144,5,6,5,98,0,0,251,
159,5,4,8,63,0,0,248,175,5,6,7,103,0,0,251,196,5,6,8,102,0,0,248,220,5,3,8,49,0,0,248,
232,5,4,10,49,0,255,248,252,5,7,8,96,0,0,248,24,6,3,8,49,0,0,248,36,6,9,5,150,0,0,251,
59,6,6,5,102,0,0,251,74,6,6,5,99,0,0,251,89,6,7,7,103,0,0,251,114,6,6,7,103,0,0,251,
135,6,5,5,71,0,0,251,148,6,5,5,86,0,0,251,161,6,5,6,69,0,0,250,176,6,6,5,102,0,0,251,
191,6,6,5,94,0,0,251,206,6,8,5,133,0,0,251,226,6,6,5,93,0,0,251,241,6,6,7,94,0,0,251,
6,7,5,5,84,0,0,251,19,7,6,8,102,0,0,248,43,7,3,9,52,0,0,249,57,7,6,8,102,0,0,248,
81,7,8,5,121,0,0,251,12,208,12,208,11,208,10,176,0,0,12,208,12,208,62,77,3,228,208,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,46,14,16,0,91,61,0,14,255,255,224,0,196,182,0,127,255,255,112,5,179,208,0,
8,134,160,0,0,72,0,10,239,245,79,136,0,63,253,145,7,223,249,0,73,218,95,255,195,0,72,0,77,229,4,192,
10,152,176,195,0,169,139,121,0,4,222,109,110,212,0,9,123,137,176,3,192,184,154,0,196,5,238,64,2,207,245,0,
7,244,0,0,6,250,0,0,46,239,133,242,127,58,252,192,95,114,239,96,8,239,205,227,62,3,224,0,0,0,0,0,
0,0,0,4,243,11,192,31,128,63,80,63,80,31,128,11,192,4,243,47,80,10,192,6,243,4,245,4,245,6,243,10,
192,46,80,0,192,9,124,166,28,249,9,124,166,0,192,0,0,0,0,0,0,0,12,80,0,0,12,80,0,31,255,255,
160,0,12,80,0,0,12,80,0,47,131,246,124,0,159,245,0,0,0,0,47,130,248,0,210,4,192,9,128,13,48,60,
0,136,0,211,0,6,222,144,63,132,247,143,64,235,159,48,220,143,64,235,63,132,247,7,222,145,15,255,48,0,143,48,
0,143,48,0,143,48,0,143,48,0,143,48,14,255,250,95,254,160,0,8,246,0,8,246,0,95,193,3,236,16,29,226,
0,95,255,248,47,254,161,0,9,246,0,9,244,5,255,177,0,23,247,0,7,247,127,254,161,0,95,224,1,223,224,8,
219,224,46,91,224,156,11,224,175,255,253,0,11,224,31,255,243,31,80,0,31,80,0,31,254,178,0,6,249,0,6,249,
111,254,161,3,207,246,30,194,0,95,96,0,127,223,195,111,162,235,46,146,234,5,222,194,127,255,249,0,7,246,0,13,
224,0,95,128,0,175,32,2,250,0,8,244,0,9,238,178,79,132,248,63,133,247,10,255,209,111,115,249,111,115,250,26,
238,195,10,238,128,127,102,245,143,102,249,27,237,250,0,2,249,0,26,243,47,253,96,15,160,15,160,0,0,15,160,15,
160,15,160,15,160,0,0,15,160,31,128,93,16,0,0,90,144,4,158,200,32,31,212,0,0,4,158,200,32,0,0,90,
144,31,255,255,160,0,0,0,0,31,255,255,160,0,0,0,0,28,130,0,0,5,174,199,16,0,1,159,160,5,174,199,
16,29,130,0,0,127,253,64,3,249,1,221,48,127,64,0,0,0,143,32,8,242,0,0,109,253,129,0,156,65,58,160,
45,27,236,123,54,133,209,215,134,105,93,29,140,51,209,190,205,112,9,196,20,176,0,7,223,214,0,0,191,176,0,47,
254,16,7,250,246,0,207,47,176,47,176,207,39,255,255,247,206,16,30,192,63,255,214,3,249,29,208,63,145,221,3,255,
255,128,63,144,191,35,249,27,243,63,255,232,0,3,190,236,1,237,50,145,127,96,0,8,244,0,0,127,96,0,1,237,
50,145,3,190,236,0,63,254,215,3,249,41,247,63,144,14,211,249,0,206,63,144,14,211,249,41,247,63,255,215,0,63,
255,247,63,144,0,63,144,0,63,255,244,63,144,0,63,144,0,63,255,248,63,255,247,63,144,0,63,144,0,63,255,244,
63,144,0,63,144,0,63,144,0,3,190,253,97,237,65,103,127,96,0,8,244,14,251,127,96,13,177,237,49,235,3,190,
237,112,63,144,15,176,63,144,15,176,63,144,15,176,63,255,255,176,63,144,15,176,63,144,15,176,63,144,15,176,63,147,
249,63,147,249,63,147,249,63,144,3,249,3,249,3,249,3,249,3,249,3,249,3,248,7,246,142,160,63,144,159,128,63,
152,248,0,63,223,144,0,63,254,32,0,63,207,210,0,63,150,252,16,63,144,111,193,63,144,0,63,144,0,63,144,0,
63,144,0,63,144,0,63,144,0,63,255,248,63,243,4,255,51,255,144,175,243,63,222,30,223,51,248,234,232,243,63,122,
249,143,51,247,95,72,243,63,112,0,143,48,63,225,14,176,63,248,14,176,63,222,30,176,63,142,142,176,63,119,238,176,
63,113,239,176,63,112,127,176,3,206,233,16,46,194,95,160,127,96,11,241,143,64,9,243,127,96,11,241,46,194,95,160,
4,206,234,16,63,255,231,3,249,27,243,63,145,191,51,255,254,128,63,144,0,3,249,0,0,63,144,0,0,3,206,233,
16,46,194,95,160,127,96,11,241,143,64,9,243,127,96,11,242,46,194,95,176,4,206,252,16,0,0,142,64,63,255,214,
3,249,30,208,63,145,236,3,255,254,48,63,148,251,3,249,10,243,63,144,95,144,9,239,229,95,113,118,95,146,0,11,
255,212,0,38,252,88,35,235,76,239,195,239,255,255,32,12,224,0,0,206,0,0,12,224,0,0,206,0,0,12,224,0,
0,206,0,0,63,144,79,131,249,4,248,63,144,79,131,249,4,248,63,144,79,128,236,24,245,5,223,232,0,206,0,30,
199,245,5,247,47,160,175,32,206,30,176,7,249,246,0,47,254,16,0,191,176,0,175,16,238,2,249,127,67,255,37,245,
63,135,205,105,242,14,186,154,156,208,12,237,103,206,160,8,255,36,255,112,5,254,0,239,64,127,96,127,96,206,62,176,
3,254,226,0,11,250,0,4,254,244,1,221,46,192,143,80,111,128,12,226,9,245,4,250,63,176,0,159,222,32,0,30,
248,0,0,10,242,0,0,10,242,0,0,10,242,0,143,255,255,0,0,143,192,0,79,226,0,29,246,0,10,250,0,6,
253,16,0,175,255,255,48,79,248,79,80,79,80,79,80,79,80,79,80,79,80,79,248,211,0,136,0,60,0,13,48,9,
128,4,192,0,210,127,246,3,246,3,246,3,246,3,246,3,246,3,246,127,246,0,127,194,0,8,179,108,48,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,15,255,248,77,16,0,121,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,79,254,144,0,6,244,77,255,246,159,71,246,77,255,246,95,96,0,5,246,0,0,95,96,
0,5,255,253,64,95,162,221,5,246,10,240,95,162,221,5,255,253,64,9,239,198,247,0,159,32,7,247,0,9,239,192,
0,0,235,0,0,235,0,0,235,27,255,251,127,100,251,159,16,235,127,100,251,27,255,251,9,238,161,127,83,247,159,255,
250,127,80,0,9,239,247,8,239,14,160,31,144,223,253,31,144,31,144,31,144,31,144,27,255,251,127,100,251,159,16,235,
127,100,251,27,255,251,0,3,249,15,254,178,95,96,0,95,96,0,95,96,0,95,255,228,95,162,234,95,96,219,95,96,
219,95,96,219,95,101,246,0,5,246,95,101,246,95,101,246,5,246,5,246,0,0,5,246,5,246,5,246,5,246,5,246,
6,245,95,176,95,96,0,5,246,0,0,95,96,0,5,246,111,128,95,191,112,5,255,209,0,95,158,177,5,246,95,176,
95,101,246,95,101,246,95,101,246,95,101,246,95,255,236,253,69,250,79,194,250,95,98,248,14,181,246,47,128,235,95,98,
248,14,176,95,255,228,95,162,234,95,96,219,95,96,219,95,96,219,9,238,177,127,99,249,159,16,220,127,99,249,9,238,
178,95,255,212,5,250,45,208,95,96,175,5,250,45,208,95,255,212,5,246,0,0,95,96,0,0,27,255,251,127,100,251,
159,16,235,127,100,251,27,255,251,0,0,235,0,0,235,95,255,117,250,16,95,96,5,246,0,95,96,0,61,255,168,247,
48,94,255,160,21,222,143,254,112,47,128,13,255,242,47,128,2,248,0,47,144,0,191,224,95,80,235,95,80,235,95,80,
235,95,116,251,11,255,251,189,1,249,95,71,243,14,171,192,9,239,112,3,254,16,158,10,224,189,95,77,227,234,31,158,
169,246,12,235,126,242,9,248,63,208,127,71,244,11,223,128,4,254,16,12,222,160,143,54,246,189,1,249,95,86,243,13,
171,192,7,255,112,1,239,16,1,218,0,47,211,0,143,255,208,8,248,6,250,5,251,0,175,255,208,0,77,245,0,143,
32,0,174,0,13,249,0,1,206,0,0,159,0,0,143,48,0,61,245,13,48,211,13,48,211,13,48,211,13,48,211,13,
48,13,232,0,0,190,0,0,159,32,0,79,245,0,159,80,0,158,0,0,190,0,13,232,0,0,0,0,0,8,235,51,
128,22,23,237,48,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,72,0,0,0,0,0,6,9,95,0,0,247,
27,0,7,9,108,0,0,247,59,0,11,9,174,0,0,247,109,0,9,11,145,0,0,247,159,0,13,9,208,0,0,247,
218,0,11,9,182,0,0,247,12,1,4,9,64,0,0,247,30,1,6,12,95,0,0,246,66,1,6,12,95,0,0,246,
102,1,7,9,109,0,0,247,134,1,11,8,174,0,0,248,178,1,5,4,79,0,0,254,188,1,5,5,86,0,0,251,
201,1,5,2,79,0,0,254,206,1,5,11,76,0,0,247,234,1,9,9,145,0,0,247,19,2,9,9,145,0,0,247,
60,2,9,9,145,0,0,247,101,2,9,9,145,0,0,247,142,2,9,9,145,0,0,247,183,2,9,9,145,0,0,247,
224,2,9,9,145,0,0,247,9,3,9,9,145,0,0,247,50,3,9,9,145,0,0,247,91,3,9,9,145,0,0,247,
132,3,5,7,83,0,0,249,150,3,5,9,83,0,0,249,173,3,11,8,174,0,0,248,217,3,11,7,174,0,0,249,
0,4,11,8,174,0,0,248,44,4,8,9,121,0,0,247,80,4,13,11,208,0,0,247,152,4,10,9,161,0,0,247,
197,4,10,9,158,0,0,247,242,4,10,9,153,0,0,247,31,5,11,9,173,0,0,247,81,5,9,9,142,0,0,247,
122,5,9,9,142,0,0,247,163,5,11,9,171,0,0,247,213,5,11,9,174,0,0,247,7,6,5,9,78,0,0,247,
30,6,6,12,78,0,255,247,66,6,11,9,161,0,0,247,116,6,8,9,132,0,0,247,152,6,13,9,207,0,0,247,
211,6,11,9,174,0,0,247,5,7,11,9,177,0,0,247,55,7,10,9,152,0,0,247,100,7,11,11,177,0,0,247,
161,7,10,9,160,0,0,247,206,7,9,9,150,0,0,247,247,7,9,9,142,0,0,247,32,8,11,9,169,0,0,247,
82,8,10,9,161,0,0,247,127,8,14,9,230,0,0,247,190,8,10,9,160,0,0,247,235,8,11,9,150,0,255,247,
29,9,9,9,151,0,0,247,70,9,6,12,95,0,0,246,106,9,5,11,76,0,0,247,134,9,6,12,95,0,0,246,
170,9,11,9,174,0,0,247,220,9,7,3,104,0,0,0,231,9,7,10,104,0,0,246,10,10,9,7,140,0,0,249,
42,10,9,10,149,0,0,246,87,10,8,7,123,0,0,249,115,10,9,10,149,0,0,246,160,10,9,7,141,0,0,249,
192,10,6,10,90,0,0,246,222,10,9,10,149,0,0,249,11,11,9,10,148,0,0,246,56,11,4,10,71,0,0,246,
76,11,5,13,71,0,255,246,109,11,9,10,138,0,0,246,154,11,4,10,71,0,0,246,174,11,14,7,217,0,0,249,
223,11,9,7,148,0,0,249,255,11,9,7,143,0,0,249,31,12,9,10,149,0,0,249,76,12,9,10,149,0,0,249,
121,12,7,7,102,0,0,249,146,12,8,7,124,0,0,249,174,12,6,9,100,0,0,247,201,12,9,7,148,0,0,249,
233,12,9,7,136,0,0,249,9,13,12,7,192,0,0,249,51,13,9,7,134,0,0,249,83,13,9,10,136,0,0,249,
128,13,8,7,121,0,0,249,156,13,9,12,148,0,0,246,210,13,5,13,76,0,0,246,243,13,9,12,148,0,0,246,
41,14,11,6,174,0,0,250,3,255,32,3,255,32,3,255,32,3,255,32,1,255,0,0,237,0,0,0,0,3,255,32,
3,255,32,12,192,249,0,204,15,144,12,192,249,0,204,15,144,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,202,11,176,0,0,47,97,247,0,7,255,255,255,255,0,0,187,10,208,0,0,14,128,218,0,3,255,
255,255,255,80,0,142,6,241,0,0,10,192,157,0,0,0,217,12,160,0,0,0,0,241,0,0,42,223,217,32,12,246,
243,120,0,239,95,16,0,11,255,251,129,0,24,207,255,208,0,0,244,239,32,198,47,62,224,4,190,254,180,0,0,15,
16,0,0,0,241,0,0,9,238,128,0,157,16,6,245,127,80,79,64,0,159,19,248,29,144,0,6,245,127,89,209,0,
0,9,238,132,244,142,234,0,0,1,217,95,117,247,0,0,141,23,243,15,144,0,79,80,95,117,247,0,13,144,0,142,
234,0,0,59,238,163,0,0,11,250,21,128,0,0,159,210,0,0,0,78,255,193,11,245,13,249,223,176,223,51,255,36,
255,191,208,63,242,7,255,247,0,191,178,62,255,64,1,141,254,203,254,80,12,192,12,192,12,192,12,192,0,0,0,0,
0,0,0,0,0,0,0,95,176,0,207,64,4,253,0,9,250,0,12,247,0,13,246,0,13,246,0,12,247,0,9,250,
0,4,253,0,0,207,64,0,95,176,11,244,0,5,251,0,0,239,48,0,175,128,0,143,176,0,111,192,0,111,192,0,
143,176,0,175,128,0,239,48,5,251,0,11,244,0,0,62,0,8,164,227,181,41,239,231,18,158,254,113,138,78,59,96,
3,224,0,0,0,0,0,0,0,0,0,0,0,0,0,0,111,64,0,0,0,6,244,0,0,0,0,111,64,0,0,175,
255,255,255,144,10,255,255,255,249,0,0,6,244,0,0,0,0,111,64,0,0,0,6,244,0,0,11,250,0,191,160,13,
227,3,247,0,95,255,181,255,251,0,0,0,0,0,0,0,0,11,250,0,191,160,0,13,160,2,245,0,126,16,11,176,
1,247,0,111,32,10,192,0,232,0,95,48,9,208,0,217,0,0,0,141,253,145,0,159,162,175,160,47,244,3,255,37,
255,32,31,246,111,242,1,255,117,255,32,31,246,47,244,3,255,32,159,162,175,160,0,141,254,145,0,9,255,255,0,0,
0,111,240,0,0,6,255,0,0,0,111,240,0,0,6,255,0,0,0,111,240,0,0,6,255,0,0,0,111,240,0,8,
255,255,255,48,4,174,253,128,0,181,20,239,128,0,0,11,252,0,0,0,223,176,0,0,159,244,0,0,159,245,0,0,
143,245,0,0,143,245,0,0,15,255,255,254,0,3,174,237,145,0,149,20,239,144,0,0,11,252,0,0,4,239,112,0,
143,255,177,0,0,3,223,176,0,0,8,255,2,164,19,223,192,6,206,237,145,0,0,3,239,242,0,2,222,255,32,1,
206,127,242,0,191,100,255,32,111,144,79,242,7,255,255,255,248,0,0,79,242,0,0,4,255,32,0,0,79,242,0,10,
255,255,248,0,175,96,0,0,10,246,0,0,0,175,255,217,16,8,98,61,251,0,0,0,127,241,0,0,7,255,32,197,
19,223,176,4,190,237,129,0,0,75,238,179,0,79,212,21,144,12,246,0,0,2,255,206,235,48,63,252,39,254,18,255,
128,31,245,13,248,1,255,64,127,194,127,209,0,125,254,162,0,63,255,255,255,0,0,0,207,224,0,0,79,248,0,0,
11,254,16,0,2,255,128,0,0,159,225,0,0,30,249,0,0,7,254,32,0,0,223,144,0,0,2,174,254,162,0,207,
161,175,192,14,246,6,255,0,175,161,175,176,2,207,255,210,1,223,129,143,209,63,243,2,255,65,239,129,143,225,3,190,
254,180,0,2,173,253,112,0,207,130,207,112,79,242,7,254,5,255,32,143,243,30,248,44,255,64,59,238,207,242,0,0,
6,253,0,149,20,223,80,3,190,235,64,0,9,252,0,159,192,0,0,0,0,0,0,0,0,159,192,9,252,0,9,252,
0,159,192,0,0,0,0,0,0,0,0,159,192,9,252,0,207,80,31,144,0,0,0,0,21,168,0,0,5,174,253,80,
4,174,253,131,0,0,175,213,0,0,0,4,174,253,131,0,0,0,5,174,253,80,0,0,0,22,168,0,0,0,0,0,
0,10,255,255,255,249,0,175,255,255,255,144,0,0,0,0,0,0,0,0,0,0,0,10,255,255,255,249,0,175,255,255,
255,144,0,0,0,0,0,0,9,165,0,0,0,0,125,254,164,0,0,0,4,157,254,147,0,0,0,6,239,144,0,4,
157,254,147,0,125,254,165,0,0,9,165,0,0,0,0,0,0,0,0,0,6,206,234,16,42,49,207,144,0,0,207,160,
0,8,255,80,0,127,245,0,0,207,144,0,0,0,0,0,0,207,128,0,0,207,128,0,0,3,173,254,181,0,0,6,
233,65,39,218,0,4,229,0,0,2,215,0,201,5,222,175,70,208,31,49,234,26,244,63,18,242,63,96,95,69,224,31,
49,234,26,246,201,0,200,5,222,175,216,0,5,228,0,0,0,0,0,7,232,49,40,193,0,0,3,174,254,181,0,0,
0,10,255,176,0,0,30,255,242,0,0,127,237,248,0,0,207,169,253,0,3,255,84,255,64,9,254,0,223,160,30,255,
255,255,241,111,225,0,14,247,207,176,0,10,252,13,255,255,216,0,13,250,4,255,96,13,250,0,223,144,13,250,3,255,
96,13,255,255,252,16,13,250,2,207,176,13,250,0,143,224,13,250,2,207,192,13,255,255,234,32,0,58,223,237,128,5,
255,130,38,144,30,250,0,0,0,95,245,0,0,0,111,244,0,0,0,95,245,0,0,0,30,250,0,0,0,5,255,130,
38,144,0,58,223,237,128,13,255,254,200,16,0,223,161,59,253,32,13,250,0,13,251,0,223,160,0,159,241,13,250,0,
7,255,32,223,160,0,159,241,13,250,0,13,251,0,223,160,59,253,32,13,255,254,216,16,0,13,255,255,252,0,223,160,
0,0,13,250,0,0,0,223,160,0,0,13,255,255,249,0,223,160,0,0,13,250,0,0,0,223,160,0,0,13,255,255,
254,0,13,255,255,252,0,223,160,0,0,13,250,0,0,0,223,160,0,0,13,255,255,249,0,223,160,0,0,13,250,0,
0,0,223,160,0,0,13,250,0,0,0,0,58,223,254,196,0,94,249,49,74,96,30,250,0,0,0,5,255,80,0,0,
0,111,244,2,255,251,5,255,80,0,175,176,30,250,0,10,251,0,95,248,33,191,176,0,58,223,238,199,0,13,250,0,
12,251,0,223,160,0,207,176,13,250,0,12,251,0,223,160,0,207,176,13,255,255,255,251,0,223,160,0,207,176,13,250,
0,12,251,0,223,160,0,207,176,13,250,0,12,251,0,13,250,0,223,160,13,250,0,223,160,13,250,0,223,160,13,250,
0,223,160,13,250,0,0,223,160,0,223,160,0,223,160,0,223,160,0,223,160,0,223,160,0,223,160,0,223,160,0,223,
160,0,223,144,5,255,80,206,198,0,13,250,0,127,248,0,223,160,143,247,0,13,250,159,246,0,0,223,239,245,0,0,
13,255,252,16,0,0,223,223,251,16,0,13,250,95,252,16,0,223,160,94,252,32,13,250,0,78,253,32,13,250,0,0,
13,250,0,0,13,250,0,0,13,250,0,0,13,250,0,0,13,250,0,0,13,250,0,0,13,250,0,0,13,255,255,254,
13,255,144,0,175,252,0,223,254,16,47,255,192,13,254,248,9,254,252,0,223,158,226,237,175,192,13,249,143,223,121,252,
0,223,145,239,225,159,192,13,249,9,248,9,252,0,223,144,0,0,159,192,13,249,0,0,9,252,0,13,255,64,10,251,
0,223,252,0,175,176,13,255,246,10,251,0,223,175,209,175,176,13,249,159,122,251,0,223,146,238,191,176,13,249,8,255,
251,0,223,144,29,255,176,13,249,0,111,251,0,0,75,239,235,64,0,111,230,22,239,96,30,249,0,8,254,21,255,80,
0,79,245,111,244,0,3,255,101,255,80,0,79,245,30,249,0,8,254,16,111,230,22,239,96,0,75,239,235,64,0,13,
255,255,216,16,13,250,3,239,144,13,250,0,175,224,13,250,0,175,224,13,250,3,239,144,13,255,255,216,16,13,250,0,
0,0,13,250,0,0,0,13,250,0,0,0,0,75,239,235,64,0,111,230,22,239,96,30,249,0,8,254,21,255,80,0,
79,245,111,244,0,3,255,101,255,80,0,79,245,30,249,0,8,254,16,111,230,22,239,112,0,75,239,254,96,0,0,0,
28,247,0,0,0,0,62,245,0,13,255,254,198,0,13,250,6,255,64,13,250,0,239,128,13,250,0,239,128,13,250,6,
254,32,13,255,255,245,0,13,250,24,255,64,13,250,0,191,209,13,250,0,63,248,2,173,254,234,0,191,129,39,160,15,
245,0,0,0,239,234,115,0,7,255,255,250,0,3,139,255,245,0,0,2,255,96,198,49,95,226,11,222,254,180,0,239,
255,255,255,192,0,207,176,0,0,12,251,0,0,0,207,176,0,0,12,251,0,0,0,207,176,0,0,12,251,0,0,0,
207,176,0,0,12,251,0,0,13,250,0,47,246,0,223,160,2,255,96,13,250,0,47,246,0,223,160,2,255,96,13,250,
0,47,246,0,223,160,2,255,96,11,251,0,63,245,0,111,228,26,253,16,0,124,239,234,48,0,207,176,0,10,252,111,
242,0,31,247,30,248,0,127,241,9,253,0,207,160,3,255,67,255,64,0,207,169,253,0,0,127,238,248,0,0,30,255,
242,0,0,10,255,176,0,143,208,3,255,128,9,253,79,242,7,255,176,12,249,31,246,10,253,224,31,246,12,250,13,216,
244,95,242,8,253,47,149,248,159,208,4,255,143,97,251,207,144,1,255,239,32,206,255,96,0,207,253,0,143,255,32,0,
143,249,0,95,253,0,95,245,0,95,245,9,254,34,239,144,1,223,187,253,16,0,62,255,227,0,0,10,255,160,0,0,
95,255,245,0,2,239,170,254,32,11,253,17,223,176,127,244,0,63,247,12,253,16,8,255,64,62,249,3,255,128,0,127,
245,207,192,0,0,191,255,227,0,0,2,239,247,0,0,0,9,254,0,0,0,0,159,224,0,0,0,9,254,0,0,0,
0,159,224,0,0,95,255,255,255,176,0,0,191,250,0,0,159,253,32,0,95,255,64,0,62,255,96,0,29,255,160,0,
11,255,193,0,6,255,226,0,0,127,255,255,255,208,13,255,241,13,245,0,13,245,0,13,245,0,13,245,0,13,245,0,
13,245,0,13,245,0,13,245,0,13,245,0,13,245,0,13,255,241,217,0,9,208,0,95,48,0,232,0,10,192,0,111,
32,1,247,0,11,176,0,126,16,2,245,0,13,160,63,255,208,0,111,208,0,111,208,0,111,208,0,111,208,0,111,208,
0,111,208,0,111,208,0,111,208,0,111,208,0,111,208,63,255,208,0,0,207,160,0,0,0,175,255,128,0,0,127,162,
191,96,0,95,128,0,158,64,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,255,255,255,128,44,193,0,0,26,176,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,13,255,253,128,0,0,3,223,96,0,0,9,250,0,
141,239,255,192,95,227,10,252,6,254,51,239,192,9,238,186,252,0,14,246,0,0,0,239,96,0,0,14,246,0,0,0,
239,156,237,80,14,253,37,255,48,239,128,12,249,14,247,0,175,176,239,128,12,249,14,253,37,255,64,239,156,237,96,1,
157,236,80,29,251,35,144,95,242,0,0,127,224,0,0,95,242,0,0,29,251,35,144,1,157,236,80,0,0,2,255,64,
0,0,47,244,0,0,2,255,64,60,237,127,244,29,248,26,255,69,255,16,79,244,127,224,2,255,69,255,16,79,244,29,
248,26,255,64,60,237,127,244,2,157,237,128,1,223,145,175,144,95,241,4,255,23,255,255,255,243,95,241,0,0,1,223,
145,38,176,2,157,253,163,0,1,190,252,8,252,16,10,251,0,207,255,250,10,251,0,10,251,0,10,251,0,10,251,0,
10,251,0,10,251,0,3,206,215,255,65,223,146,175,244,95,241,4,255,71,254,0,47,244,95,241,4,255,65,223,129,175,
244,3,206,216,255,64,0,0,79,242,8,98,60,250,0,42,238,199,0,14,246,0,0,0,239,96,0,0,14,246,0,0,
0,239,155,238,112,14,253,38,255,32,239,128,47,244,14,246,1,255,64,239,96,31,244,14,246,1,255,64,239,96,31,244,
14,246,14,246,0,0,14,246,14,246,14,246,14,246,14,246,14,246,14,246,0,239,96,14,246,0,0,0,14,246,0,239,
96,14,246,0,239,96,14,246,0,239,96,14,246,0,239,96,63,243,127,215,0,14,246,0,0,0,239,96,0,0,14,246,
0,0,0,239,96,159,227,14,246,159,211,0,239,223,210,0,14,255,248,0,0,239,175,247,0,14,246,95,247,0,239,96,
111,247,14,246,14,246,14,246,14,246,14,246,14,246,14,246,14,246,14,246,14,246,14,249,206,213,158,234,0,14,253,41,
255,130,239,96,14,247,6,255,16,207,128,14,246,6,254,0,207,144,14,246,6,254,0,207,144,14,246,6,254,0,207,144,
14,246,6,254,0,207,144,14,249,190,231,0,239,210,111,242,14,248,2,255,64,239,96,31,244,14,246,1,255,64,239,96,
31,244,14,246,1,255,64,2,157,253,145,1,223,129,159,192,95,241,2,255,71,254,0,31,246,95,241,2,255,65,223,129,
159,192,2,157,253,145,0,14,249,206,213,0,239,210,95,243,14,248,0,207,144,239,112,10,251,14,248,0,207,144,239,210,
95,244,14,249,206,214,0,239,96,0,0,14,246,0,0,0,239,96,0,0,3,206,215,255,65,223,129,175,244,95,241,4,
255,71,254,0,47,244,95,241,4,255,65,223,129,175,244,3,206,215,255,64,0,0,47,244,0,0,2,255,64,0,0,47,
244,14,249,206,112,239,211,0,14,248,0,0,239,96,0,14,246,0,0,239,96,0,14,246,0,0,7,223,218,32,79,209,
39,144,95,231,81,0,10,255,255,144,0,20,159,241,74,65,95,225,6,206,236,80,11,249,0,11,249,0,223,255,254,11,
249,0,11,249,0,11,249,0,11,249,0,10,251,0,3,207,251,15,245,2,255,48,255,80,47,243,15,245,2,255,48,255,
80,47,243,15,245,4,255,48,223,145,175,243,4,223,215,255,48,175,160,3,255,36,255,16,159,176,12,247,14,245,0,127,
197,253,0,1,239,207,128,0,10,255,242,0,0,79,251,0,0,127,192,47,242,12,247,63,241,111,246,31,243,13,245,158,
233,95,224,10,249,219,189,159,160,6,253,247,127,223,96,2,255,243,63,255,32,0,223,224,14,253,0,95,227,11,251,0,
159,199,253,16,1,207,255,64,0,5,255,176,0,1,223,255,96,0,191,181,254,48,127,226,9,252,16,175,160,4,255,36,
255,32,159,176,12,247,14,246,0,111,212,254,16,1,239,207,160,0,9,255,245,0,0,47,254,0,0,0,207,144,0,0,
62,243,0,0,191,214,0,0,95,255,255,224,0,3,239,224,0,46,255,80,1,223,247,0,27,255,144,0,127,250,0,0,
127,255,255,224,0,1,174,250,0,0,111,226,0,0,7,252,0,0,0,127,192,0,0,44,250,0,0,127,254,32,0,0,
44,249,0,0,0,143,176,0,0,7,252,0,0,0,127,192,0,0,5,254,48,0,0,10,239,160,6,242,0,111,32,6,
242,0,111,32,6,242,0,111,32,6,242,0,111,32,6,242,0,111,32,6,242,0,111,32,6,242,0,7,254,195,0,0,
1,191,144,0,0,8,251,0,0,0,143,176,0,0,6,254,48,0,0,12,255,160,0,6,254,48,0,0,143,176,0,0,
8,251,0,0,0,159,160,0,0,28,249,0,0,127,235,32,0,0,0,0,0,0,0,42,237,147,23,128,10,255,255,255,
248,0,134,19,158,234,16,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,25,21,138,1,0,235,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,7,1,21,21,78,1,0,235,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,228,1,20,16,59,1,0,240,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,132,2,21,22,
76,1,0,240,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,107,3,17,16,20,1,0,240,0,0,0,3,
139,222,254,218,113,0,0,0,0,0,0,59,255,255,255,255,255,232,16,0,0,0,0,110,255,255,255,255,255,255,252,32,
0,0,0,95,255,255,255,255,255,255,255,253,16,0,0,46,255,255,252,98,19,142,255,255,250,0,0,9,255,255,251,0,
0,0,62,255,255,243,0,0,239,255,254,16,0,0,0,95,255,255,144,0,79,255,255,144,0,0,0,0,223,255,253,0,
7,255,255,245,0,0,0,0,10,255,255,241,0,143,255,255,48,0,0,0,0,143,255,255,32,9,255,255,242,0,0,0,
0,7,255,255,243,0,143,255,255,48,0,0,0,0,143,255,255,32,7,255,255,245,0,0,0,0,10,255,255,241,0,79,
255,255,144,0,0,0,0,223,255,253,0,0,239,255,254,16,0,0,0,95,255,255,144,0,9,255,255,251,0,0,0,62,
255,255,243,0,0,46,255,255,252,82,19,126,255,255,250,0,0,0,95,255,255,255,255,255,255,255,253,16,0,0,0,110,
255,255,255,255,255,255,252,32,0,0,0,0,59,255,255,255,255,255,233,16,0,0,0,0,0,3,139,222,254,218,113,0,
0,0,0,0,0,3,156,239,254,220,151,48,0,0,0,26,255,255,255,255,255,255,96,0,0,11,255,255,255,255,255,255,
247,0,0,6,255,255,255,255,255,255,255,112,0,0,191,255,253,98,1,55,191,247,0,0,13,255,255,64,0,0,0,41,
96,0,0,239,255,242,0,0,0,0,0,0,0,13,255,255,161,0,0,0,0,0,0,0,159,255,255,235,133,32,0,0,
0,0,2,239,255,255,255,255,234,64,0,0,0,4,223,255,255,255,255,255,178,0,0,0,1,141,255,255,255,255,255,209,
0,0,0,0,3,105,207,255,255,255,112,0,0,0,0,0,0,23,255,255,250,0,0,0,0,0,0,0,10,255,255,192,
0,10,130,0,0,0,0,175,255,251,0,0,207,251,116,33,20,159,255,255,144,0,12,255,255,255,255,255,255,255,244,0,
0,207,255,255,255,255,255,255,249,0,0,7,223,255,255,255,255,255,249,0,0,0,0,71,172,239,254,219,130,0,0,0,
0,0,2,139,239,237,182,0,0,0,0,0,159,255,255,255,255,211,0,0,0,11,255,255,255,255,255,254,48,0,0,159,
255,254,97,40,255,255,209,0,2,255,255,246,0,0,175,255,247,0,7,255,255,208,0,0,63,255,253,0,10,255,255,160,
0,0,15,255,255,16,11,255,255,255,255,255,255,255,255,48,11,255,255,255,255,255,255,255,255,80,10,255,255,255,255,255,
255,255,255,80,7,255,255,144,0,0,0,0,0,0,2,255,255,226,0,0,0,1,136,0,0,159,255,253,115,17,54,191,
249,0,0,27,255,255,255,255,255,255,249,0,0,1,159,255,255,255,255,254,129,0,0,0,2,139,222,254,202,81,0,0,
0,159,255,248,2,157,254,198,0,0,0,9,255,255,133,239,255,255,252,16,0,0,159,255,250,239,255,255,255,251,0,0,
9,255,255,254,97,40,255,255,247,0,0,159,255,255,80,0,9,255,255,208,0,9,255,255,208,0,0,47,255,255,48,0,
159,255,250,0,0,0,239,255,246,0,9,255,255,144,0,0,13,255,255,112,0,159,255,249,0,0,0,223,255,247,0,9,
255,255,160,0,0,14,255,255,96,0,159,255,253,0,0,2,255,255,243,0,9,255,255,245,0,0,159,255,253,0,0,159,
255,255,230,18,143,255,255,112,0,9,255,255,174,255,255,255,255,192,0,0,159,255,248,94,255,255,255,193,0,0,9,255,
255,128,41,223,236,96,0,0,0,159,255,248,0,0,0,0,0,0,0,9,255,255,128,0,0,0,0,0,0,0,159,255,
248,0,0,0,0,0,0,0,9,255,255,128,0,0,0,0,0,0,0,159,255,248,0,0,0,0,0,0,0,9,255,255,
128,0,0,0,0,0,0,0,1,123,222,254,200,48,0,0,4,239,255,255,255,255,179,0,1,239,255,255,255,255,255,208,
0,111,255,250,49,20,141,253,0,8,255,255,16,0,0,5,160,0,127,255,246,0,0,0,0,0,3,255,255,253,185,116,
16,0,0,10,255,255,255,255,254,163,0,0,6,207,255,255,255,255,227,0,0,0,37,138,207,255,255,160,0,0,0,0,
0,79,255,253,0,89,32,0,0,1,255,255,208,5,255,166,49,19,175,255,251,0,95,255,255,255,255,255,255,80,0,125,
255,255,255,255,255,112,0,0,5,156,239,237,184,32,0,0,0,0,18,18,24,1,0,238,0,0,0,0,0,0,0,0,
162,0,10,9,160,0,0,247,207,0,8,3,133,0,0,253,0,0,0,0,0,0,0,0,219,0,17,21,11,1,0,235,
142,1,17,21,11,1,0,235,65,2,17,21,11,1,0,235,244,2,17,21,11,1,0,235,167,3,17,21,11,1,0,235,
90,4,17,21,11,1,0,235,13,5,17,21,11,1,0,235,192,5,17,21,11,1,0,235,115,6,17,21,11,1,0,235,
38,7,17,21,11,1,0,235,217,7,8,16,133,0,0,240,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
25,8,20,21,64,1,0,235,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
235,8,17,16,11,1,0,240,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,115,9,17,16,11,1,0,240,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,251,9,10,16,160,0,0,240,0,0,0,2,84,0,0,0,0,0,0,0,6,253,0,0,
0,0,0,0,0,6,253,0,0,0,0,0,0,0,6,253,0,0,0,0,0,0,0,6,253,0,0,0,0,0,0,0,
6,253,0,0,0,0,0,0,0,6,253,0,0,0,0,9,255,255,255,255,255,255,255,16,9,255,255,255,255,255,255,255,
16,2,51,51,55,253,51,51,51,0,0,0,0,6,253,0,0,0,0,0,0,0,6,253,0,0,0,0,0,0,0,6,
253,0,0,0,0,0,0,0,6,253,0,0,0,0,0,0,0,6,253,0,0,0,0,0,0,0,3,118,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,11,255,255,255,176,11,255,255,255,176,4,102,102,102,
64,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
95,250,0,0,95,250,0,0,95,250,0,0,0,24,206,254,182,0,0,0,0,61,255,255,255,251,16,0,0,46,255,149,
53,191,250,0,0,9,255,96,0,0,175,244,0,1,239,192,0,0,2,255,160,0,95,247,0,0,0,11,254,0,8,255,
48,0,0,0,143,243,0,175,241,0,0,0,6,255,96,12,254,0,0,0,0,95,247,0,207,208,0,0,0,4,255,128,
13,253,0,0,0,0,63,248,0,207,208,0,0,0,4,255,128,12,254,0,0,0,0,95,247,0,175,241,0,0,0,6,
255,80,8,255,48,0,0,0,159,243,0,79,247,0,0,0,12,254,0,0,239,192,0,0,3,255,144,0,8,255,112,0,
1,207,243,0,0,29,255,165,70,207,248,0,0,0,61,255,255,255,249,0,0,0,0,23,206,253,165,0,0,0,0,0,
0,60,255,64,0,0,0,0,0,110,255,244,0,0,0,0,1,175,253,255,64,0,0,0,1,223,229,143,244,0,0,0,
0,47,194,8,255,64,0,0,0,2,144,0,143,244,0,0,0,0,0,0,8,255,64,0,0,0,0,0,0,143,244,0,
0,0,0,0,0,8,255,64,0,0,0,0,0,0,143,244,0,0,0,0,0,0,8,255,64,0,0,0,0,0,0,143,
244,0,0,0,0,0,0,8,255,64,0,0,0,0,0,0,143,244,0,0,0,0,0,0,8,255,64,0,0,0,0,0,
0,143,244,0,0,0,0,0,0,8,255,64,0,0,0,0,0,0,143,244,0,0,0,0,52,68,73,255,116,68,65,0,
11,255,255,255,255,255,255,64,0,191,255,255,255,255,255,244,0,0,0,40,206,254,200,32,0,0,0,110,255,255,255,254,
64,0,0,95,255,165,70,207,254,32,0,13,255,80,0,0,175,248,0,3,255,176,0,0,2,255,192,0,56,165,0,0,
0,14,253,0,0,0,0,0,0,0,239,192,0,0,0,0,0,0,79,248,0,0,0,0,0,0,12,254,32,0,0,0,
0,0,9,255,112,0,0,0,0,0,10,255,160,0,0,0,0,0,27,255,160,0,0,0,0,0,45,255,128,0,0,0,
0,0,78,255,96,0,0,0,0,0,78,254,64,0,0,0,0,0,62,253,48,0,0,0,0,0,29,253,32,0,0,0,
0,0,10,255,64,0,0,0,0,0,3,255,180,68,68,68,68,65,0,143,255,255,255,255,255,255,48,8,255,255,255,255,
255,255,243,0,0,0,57,222,254,200,16,0,0,0,143,255,255,255,254,64,0,0,127,254,133,70,207,254,32,0,30,254,
48,0,0,175,248,0,6,255,128,0,0,3,255,176,0,72,147,0,0,0,14,252,0,0,0,0,0,0,2,255,160,0,
0,0,0,0,0,159,245,0,0,0,0,0,37,207,249,0,0,0,0,14,255,255,181,0,0,0,0,0,239,255,235,96,
0,0,0,0,5,86,140,255,193,0,0,0,0,0,0,7,255,176,0,0,0,0,0,0,11,255,48,0,0,0,0,0,
0,127,246,0,139,193,0,0,0,7,255,96,10,255,80,0,0,0,191,244,0,95,253,32,0,0,95,253,0,0,191,254,
133,70,175,255,96,0,1,191,255,255,255,255,112,0,0,0,90,222,254,201,48,0,0,0,0,0,0,4,255,224,0,0,
0,0,0,1,223,254,0,0,0,0,0,0,159,255,224,0,0,0,0,0,79,252,254,0,0,0,0,0,29,249,159,224,
0,0,0,0,9,253,25,254,0,0,0,0,5,255,80,159,224,0,0,0,1,223,160,9,254,0,0,0,0,175,209,0,
159,224,0,0,0,95,245,0,9,254,0,0,0,30,249,0,0,159,224,0,0,10,253,16,0,9,254,0,0,5,255,64,
0,0,159,224,0,2,239,128,0,0,9,254,0,0,111,255,255,255,255,255,255,253,6,255,255,255,255,255,255,255,208,18,
34,34,34,34,175,226,33,0,0,0,0,0,9,254,0,0,0,0,0,0,0,159,224,0,0,0,0,0,0,9,254,0,
0,0,0,0,0,0,159,224,0,0,0,159,255,255,255,255,255,64,0,10,255,255,255,255,255,244,0,0,191,228,68,68,
68,68,16,0,12,253,0,0,0,0,0,0,0,223,192,0,0,0,0,0,0,13,251,0,0,0,0,0,0,0,239,160,
0,0,0,0,0,0,15,249,91,239,236,130,0,0,2,255,239,255,255,255,229,0,0,63,255,215,68,107,255,227,0,2,
170,129,0,0,9,255,176,0,0,0,0,0,0,13,255,32,0,0,0,0,0,0,143,246,0,0,0,0,0,0,6,255,
112,0,0,0,0,0,0,111,246,0,1,48,0,0,0,9,255,64,10,255,64,0,0,1,223,225,0,111,252,16,0,0,
159,249,0,0,207,253,116,70,207,253,16,0,2,207,255,255,255,252,32,0,0,0,107,223,254,182,0,0,0,0,0,3,
157,239,217,32,0,0,0,6,239,255,255,254,80,0,0,5,255,231,68,143,254,32,0,1,223,226,0,0,111,249,0,0,
127,246,0,0,0,151,64,0,12,253,0,0,0,0,0,0,1,255,160,0,0,0,0,0,0,79,247,0,0,0,0,0,
0,6,255,81,124,239,218,48,0,0,127,245,207,255,255,255,112,0,8,255,222,131,19,142,255,80,0,143,255,64,0,0,
79,253,0,7,255,160,0,0,0,175,243,0,111,247,0,0,0,7,255,80,3,255,128,0,0,0,111,246,0,14,250,0,
0,0,7,255,80,0,175,225,0,0,0,191,242,0,3,255,160,0,0,95,251,0,0,9,255,197,52,159,254,48,0,0,
10,255,255,255,254,80,0,0,0,5,174,254,201,32,0,0,8,255,255,255,255,255,255,243,0,143,255,255,255,255,255,255,
48,2,68,68,68,68,68,191,225,0,0,0,0,0,0,79,246,0,0,0,0,0,0,29,251,0,0,0,0,0,0,8,
254,48,0,0,0,0,0,2,239,128,0,0,0,0,0,0,175,225,0,0,0,0,0,0,63,246,0,0,0,0,0,0,
10,253,0,0,0,0,0,0,3,255,112,0,0,0,0,0,0,159,225,0,0,0,0,0,0,30,250,0,0,0,0,0,
0,6,255,80,0,0,0,0,0,0,175,225,0,0,0,0,0,0,14,251,0,0,0,0,0,0,3,255,144,0,0,0,
0,0,0,111,246,0,0,0,0,0,0,8,255,64,0,0,0,0,0,0,175,243,0,0,0,0,0,0,10,255,48,0,
0,0,0,0,0,57,222,254,200,16,0,0,0,143,255,255,255,254,64,0,0,127,253,82,3,142,254,32,0,14,254,32,
0,0,127,249,0,3,255,160,0,0,1,255,192,0,63,249,0,0,0,14,253,0,1,255,176,0,0,1,255,176,0,11,
254,48,0,0,111,246,0,0,62,253,98,19,143,251,0,0,0,42,255,255,255,216,0,0,0,4,190,255,255,254,162,0,
0,6,255,197,17,55,239,227,0,2,239,192,0,0,2,239,192,0,143,245,0,0,0,9,255,48,11,255,16,0,0,0,
127,246,0,191,242,0,0,0,7,255,96,9,255,80,0,0,0,175,244,0,79,252,0,0,0,46,254,0,0,191,252,81,
2,109,255,96,0,1,191,255,255,255,255,112,0,0,0,90,222,254,201,48,0,0,0,0,41,222,253,164,0,0,0,0,
111,255,255,255,249,0,0,0,95,254,132,55,223,247,0,0,13,255,64,0,2,223,226,0,5,255,144,0,0,5,255,112,
0,143,245,0,0,0,14,252,0,9,255,48,0,0,0,191,224,0,159,243,0,0,0,10,255,32,8,255,80,0,0,0,
191,244,0,95,249,0,0,0,30,255,64,0,239,244,0,0,10,255,245,0,6,255,231,50,92,252,255,64,0,8,255,255,
255,249,127,243,0,0,4,190,254,181,9,255,0,0,0,0,0,0,0,207,208,0,0,0,0,0,0,31,249,0,1,121,
96,0,0,8,255,64,0,13,254,32,0,4,255,176,0,0,127,253,99,72,239,227,0,0,0,175,255,255,255,212,0,0,
0,0,107,239,236,129,0,0,0,0,95,250,0,0,95,250,0,0,95,250,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,95,250,
0,0,95,250,0,0,95,250,0,0,159,255,255,255,255,255,255,255,48,0,159,255,255,255,255,255,255,255,48,0,159,248,
85,85,85,85,85,85,16,0,159,245,0,0,0,0,0,0,0,0,159,245,0,0,0,0,0,0,0,0,159,245,0,0,
0,0,0,0,0,0,159,245,0,0,0,0,0,0,0,0,159,245,0,0,0,0,0,0,0,0,159,245,0,0,0,0,
0,0,0,0,159,255,255,255,255,255,255,244,0,0,159,255,255,255,255,255,255,244,0,0,159,248,85,85,85,85,85,81,
0,0,159,245,0,0,0,0,0,0,0,0,159,245,0,0,0,0,0,0,0,0,159,245,0,0,0,0,0,0,0,0,
159,245,0,0,0,0,0,0,0,0,159,245,0,0,0,0,0,0,0,0,159,245,0,0,0,0,0,0,0,0,159,248,
85,85,85,85,85,85,64,0,159,255,255,255,255,255,255,255,176,0,159,255,255,255,255,255,255,255,176,0,0,41,206,254,
183,0,0,0,0,94,255,255,255,253,32,0,0,79,254,97,2,143,252,0,0,13,255,64,0,0,127,247,0,4,255,160,
0,0,0,239,192,0,143,245,0,0,0,10,255,16,10,255,48,0,0,0,143,244,0,191,255,255,255,255,255,255,80,11,
255,255,255,255,255,255,246,0,175,242,0,0,0,0,0,0,8,255,64,0,0,0,0,0,0,79,248,0,0,0,0,0,
0,0,223,226,0,0,0,188,112,0,4,255,230,32,37,207,246,0,0,6,239,255,255,255,248,0,0,0,2,140,239,237,
147,0,0,0,0,57,222,254,200,32,0,0,0,127,255,255,255,254,80,0,0,111,253,97,2,126,254,48,0,13,254,32,
0,0,95,250,0,5,255,144,0,0,0,223,225,0,143,245,0,0,0,9,255,64,10,255,32,0,0,0,127,246,0,191,
241,0,0,0,6,255,112,11,255,16,0,0,0,111,247,0,175,242,0,0,0,7,255,96,8,255,80,0,0,0,159,243,
0,95,249,0,0,0,13,254,0,0,223,226,0,0,6,255,144,0,5,255,213,16,40,255,226,0,0,6,255,255,255,255,
211,0,0,0,3,157,239,235,113,0,0,0,255,128,141,248,0,239,152,255,248,0,239,174,216,133,0,239,237,16,0,0,
239,245,0,0,0,239,224,0,0,0,239,192,0,0,0,239,192,0,0,0,239,176,0,0,0,239,176,0,0,0,239,176,
0,0,0,239,176,0,0,0,239,176,0,0,0,239,176,0,0,0,239,176,0,0,0,239,176,0,0,0,0,0,29,38,
175,1,0,219,39,2,29,36,175,1,0,220,49,4,29,37,175,1,0,219,74,6,29,38,175,1,0,219,113,8,29,36,
175,1,0,220,123,10,29,37,175,1,0,220,148,12,29,38,175,1,0,219,187,14,29,36,175,1,0,220,197,16,29,38,
175,1,0,219,236,18,29,38,175,1,0,219,19,21,14,27,199,0,0,229,0,0,0,0,2,123,222,254,219,114,0,0,
0,0,0,0,0,0,25,255,255,255,255,255,249,16,0,0,0,0,0,0,61,255,255,255,255,255,255,252,32,0,0,0,
0,0,62,255,255,254,220,222,255,255,253,16,0,0,0,0,12,255,255,214,16,0,22,223,255,251,0,0,0,0,7,255,
255,194,0,0,0,2,207,255,245,0,0,0,0,223,255,226,0,0,0,0,3,239,255,192,0,0,0,95,255,247,0,0,
0,0,0,8,255,255,64,0,0,10,255,254,16,0,0,0,0,0,47,255,249,0,0,0,239,255,160,0,0,0,0,0,
0,207,255,208,0,0,63,255,247,0,0,0,0,0,0,8,255,255,32,0,6,255,255,64,0,0,0,0,0,0,95,255,
245,0,0,159,255,241,0,0,0,0,0,0,3,255,255,128,0,11,255,254,0,0,0,0,0,0,0,31,255,249,0,0,
207,255,208,0,0,0,0,0,0,0,239,255,176,0,13,255,252,0,0,0,0,0,0,0,13,255,252,0,0,239,255,176,
0,0,0,0,0,0,0,223,255,208,0,14,255,251,0,0,0,0,0,0,0,12,255,253,0,0,239,255,176,0,0,0,
0,0,0,0,207,255,208,0,15,255,251,0,0,0,0,0,0,0,12,255,253,0,0,239,255,176,0,0,0,0,0,0,
0,207,255,208,0,14,255,251,0,0,0,0,0,0,0,13,255,253,0,0,223,255,192,0,0,0,0,0,0,0,223,255,
192,0,12,255,253,0,0,0,0,0,0,0,15,255,251,0,0,175,255,224,0,0,0,0,0,0,2,255,255,144,0,8,
255,255,32,0,0,0,0,0,0,79,255,247,0,0,111,255,244,0,0,0,0,0,0,7,255,255,64,0,2,255,255,128,
0,0,0,0,0,0,175,255,241,0,0,13,255,251,0,0,0,0,0,0,13,255,252,0,0,0,159,255,242,0,0,0,
0,0,5,255,255,112,0,0,4,255,255,128,0,0,0,0,0,191,255,242,0,0,0,12,255,255,48,0,0,0,0,95,
255,250,0,0,0,0,95,255,253,32,0,0,0,78,255,255,32,0,0,0,0,175,255,254,113,0,2,142,255,255,112,0,
0,0,0,1,207,255,255,253,205,255,255,255,160,0,0,0,0,0,2,207,255,255,255,255,255,255,161,0,0,0,0,0,
0,1,142,255,255,255,255,254,96,0,0,0,0,0,0,0,0,23,189,239,237,166,16,0,0,0,0,0,0,0,0,0,
0,110,255,251,0,0,0,0,0,0,0,0,0,0,2,191,255,255,176,0,0,0,0,0,0,0,0,0,6,239,255,255,
251,0,0,0,0,0,0,0,0,0,43,255,255,255,255,176,0,0,0,0,0,0,0,0,110,255,255,206,255,251,0,0,
0,0,0,0,0,0,191,255,255,128,239,255,176,0,0,0,0,0,0,0,15,255,253,64,14,255,251,0,0,0,0,0,
0,0,0,255,249,16,0,239,255,176,0,0,0,0,0,0,0,15,229,0,0,14,255,251,0,0,0,0,0,0,0,0,
161,0,0,0,239,255,176,0,0,0,0,0,0,0,0,0,0,0,14,255,251,0,0,0,0,0,0,0,0,0,0,0,
0,239,255,176,0,0,0,0,0,0,0,0,0,0,0,14,255,251,0,0,0,0,0,0,0,0,0,0,0,0,239,255,
176,0,0,0,0,0,0,0,0,0,0,0,14,255,251,0,0,0,0,0,0,0,0,0,0,0,0,239,255,176,0,0,
0,0,0,0,0,0,0,0,0,14,255,251,0,0,0,0,0,0,0,0,0,0,0,0,239,255,176,0,0,0,0,0,
0,0,0,0,0,0,14,255,251,0,0,0,0,0,0,0,0,0,0,0,0,239,255,176,0,0,0,0,0,0,0,0,
0,0,0,14,255,251,0,0,0,0,0,0,0,0,0,0,0,0,239,255,176,0,0,0,0,0,0,0,0,0,0,0,
14,255,251,0,0,0,0,0,0,0,0,0,0,0,0,239,255,176,0,0,0,0,0,0,0,0,0,0,0,14,255,251,
0,0,0,0,0,0,0,0,0,0,0,0,239,255,176,0,0,0,0,0,0,0,0,0,0,0,14,255,251,0,0,0,
0,0,0,0,0,0,0,0,0,239,255,176,0,0,0,0,0,0,0,0,0,0,0,14,255,251,0,0,0,0,0,0,
0,0,0,0,0,0,239,255,176,0,0,0,0,0,0,0,0,0,0,0,14,255,251,0,0,0,0,0,0,0,0,0,
0,0,0,239,255,176,0,0,0,0,0,0,1,238,238,238,238,239,255,255,238,238,238,238,96,0,0,31,255,255,255,255,
255,255,255,255,255,255,247,0,0,1,255,255,255,255,255,255,255,255,255,255,255,112,0,0,31,255,255,255,255,255,255,255,
255,255,255,247,0,0,0,0,0,3,139,222,254,220,149,0,0,0,0,0,0,0,0,59,255,255,255,255,255,253,96,0,
0,0,0,0,0,143,255,255,255,255,255,255,255,161,0,0,0,0,0,159,255,255,255,220,223,255,255,255,160,0,0,0,
0,111,255,255,198,16,0,22,223,255,255,96,0,0,0,30,255,255,144,0,0,0,1,191,255,253,0,0,0,7,255,255,
176,0,0,0,0,1,223,255,244,0,0,0,207,255,243,0,0,0,0,0,7,255,255,128,0,0,31,255,252,0,0,0,
0,0,0,63,255,250,0,0,1,121,171,112,0,0,0,0,0,0,255,255,176,0,0,0,0,0,0,0,0,0,0,0,
15,255,251,0,0,0,0,0,0,0,0,0,0,0,2,255,255,144,0,0,0,0,0,0,0,0,0,0,0,95,255,247,
0,0,0,0,0,0,0,0,0,0,0,11,255,255,32,0,0,0,0,0,0,0,0,0,0,4,255,255,160,0,0,0,
0,0,0,0,0,0,0,1,223,255,242,0,0,0,0,0,0,0,0,0,0,0,191,255,248,0,0,0,0,0,0,0,
0,0,0,0,159,255,251,0,0,0,0,0,0,0,0,0,0,0,175,255,253,16,0,0,0,0,0,0,0,0,0,1,
191,255,253,32,0,0,0,0,0,0,0,0,0,3,223,255,252,32,0,0,0,0,0,0,0,0,0,4,239,255,252,16,
0,0,0,0,0,0,0,0,0,7,255,255,250,16,0,0,0,0,0,0,0,0,0,8,255,255,248,0,0,0,0,0,
0,0,0,0,0,10,255,255,246,0,0,0,0,0,0,0,0,0,0,10,255,255,228,0,0,0,0,0,0,0,0,0,
0,9,255,255,211,0,0,0,0,0,0,0,0,0,0,7,255,255,210,0,0,0,0,0,0,0,0,0,0,5,255,255,
210,0,0,0,0,0,0,0,0,0,0,2,239,255,226,0,0,0,0,0,0,0,0,0,0,0,191,255,245,0,0,0,
0,0,0,0,0,0,0,0,95,255,249,0,0,0,0,0,0,0,0,0,0,0,12,255,254,16,0,0,0,0,0,0,
0,0,0,0,5,255,255,254,238,238,238,238,238,238,238,238,229,0,0,127,255,255,255,255,255,255,255,255,255,255,255,96,
0,7,255,255,255,255,255,255,255,255,255,255,255,246,0,0,127,255,255,255,255,255,255,255,255,255,255,255,96,0,0,0,
0,0,5,156,222,254,219,131,0,0,0,0,0,0,0,0,109,255,255,255,255,255,252,64,0,0,0,0,0,1,191,255,
255,255,255,255,255,255,128,0,0,0,0,1,207,255,255,254,220,223,255,255,255,128,0,0,0,0,175,255,255,163,0,0,
23,223,255,255,64,0,0,0,95,255,254,80,0,0,0,2,207,255,252,0,0,0,11,255,255,96,0,0,0,0,2,239,
255,242,0,0,1,255,255,192,0,0,0,0,0,9,255,255,112,0,0,95,255,247,0,0,0,0,0,0,95,255,249,0,
0,3,120,154,48,0,0,0,0,0,2,255,255,160,0,0,0,0,0,0,0,0,0,0,0,47,255,250,0,0,0,0,
0,0,0,0,0,0,0,3,255,255,144,0,0,0,0,0,0,0,0,0,0,0,111,255,246,0,0,0,0,0,0,0,
0,0,0,0,12,255,254,16,0,0,0,0,0,0,0,0,0,0,7,255,255,144,0,0,0,0,0,0,0,0,0,0,
24,255,255,209,0,0,0,0,0,0,0,0,1,37,141,255,255,210,0,0,0,0,0,0,0,7,255,255,255,255,255,145,
0,0,0,0,0,0,0,0,127,255,255,255,200,32,0,0,0,0,0,0,0,0,7,255,255,255,255,217,64,0,0,0,
0,0,0,0,0,127,255,255,255,255,255,195,0,0,0,0,0,0,0,0,0,1,54,174,255,255,229,0,0,0,0,0,
0,0,0,0,0,0,26,255,255,227,0,0,0,0,0,0,0,0,0,0,0,8,255,255,176,0,0,0,0,0,0,0,
0,0,0,0,12,255,255,48,0,0,0,0,0,0,0,0,0,0,0,127,255,247,0,0,0,0,0,0,0,0,0,0,
0,4,255,255,144,0,0,0,18,0,0,0,0,0,0,0,63,255,250,0,0,189,239,208,0,0,0,0,0,0,4,255,
255,144,0,12,255,255,32,0,0,0,0,0,0,127,255,248,0,0,159,255,248,0,0,0,0,0,0,11,255,255,80,0,
3,255,255,227,0,0,0,0,0,5,255,255,225,0,0,11,255,255,211,0,0,0,0,4,239,255,249,0,0,0,62,255,
255,249,48,0,0,74,255,255,254,16,0,0,0,95,255,255,255,237,205,239,255,255,254,64,0,0,0,0,94,255,255,255,
255,255,255,255,253,64,0,0,0,0,0,25,239,255,255,255,255,255,233,16,0,0,0,0,0,0,1,105,206,239,237,201,
97,0,0,0,0,0,0,0,0,0,0,0,0,12,255,255,112,0,0,0,0,0,0,0,0,0,0,8,255,255,247,0,
0,0,0,0,0,0,0,0,0,3,255,255,255,112,0,0,0,0,0,0,0,0,0,0,207,255,255,247,0,0,0,0,
0,0,0,0,0,0,143,255,255,255,112,0,0,0,0,0,0,0,0,0,79,255,223,255,247,0,0,0,0,0,0,0,
0,0,29,255,246,239,255,112,0,0,0,0,0,0,0,0,9,255,252,14,255,247,0,0,0,0,0,0,0,0,4,255,
255,48,239,255,112,0,0,0,0,0,0,0,1,223,255,112,14,255,247,0,0,0,0,0,0,0,0,159,255,192,0,239,
255,112,0,0,0,0,0,0,0,95,255,227,0,14,255,247,0,0,0,0,0,0,0,29,255,247,0,0,239,255,112,0,
0,0,0,0,0,10,255,251,0,0,14,255,247,0,0,0,0,0,0,5,255,254,32,0,0,239,255,112,0,0,0,0,
0,2,239,255,96,0,0,14,255,247,0,0,0,0,0,0,191,255,176,0,0,0,239,255,112,0,0,0,0,0,111,255,
226,0,0,0,14,255,247,0,0,0,0,0,46,255,246,0,0,0,0,239,255,112,0,0,0,0,11,255,250,0,0,0,
0,14,255,247,0,0,0,0,7,255,254,16,0,0,0,0,239,255,112,0,0,0,3,239,255,80,0,0,0,0,14,255,
247,0,0,0,0,207,255,144,0,0,0,0,0,239,255,112,0,0,0,127,255,193,0,0,0,0,0,14,255,247,0,0,
0,13,255,255,255,255,255,255,255,255,255,255,255,255,247,0,223,255,255,255,255,255,255,255,255,255,255,255,255,112,13,255,
255,255,255,255,255,255,255,255,255,255,255,247,0,138,170,170,170,170,170,170,170,175,255,252,170,170,64,0,0,0,0,0,
0,0,0,0,239,255,112,0,0,0,0,0,0,0,0,0,0,0,14,255,247,0,0,0,0,0,0,0,0,0,0,0,
0,239,255,112,0,0,0,0,0,0,0,0,0,0,0,14,255,247,0,0,0,0,0,0,0,0,0,0,0,0,239,255,
112,0,0,0,0,0,0,0,0,0,0,0,14,255,247,0,0,0,0,0,0,0,0,0,0,0,0,239,255,112,0,0,
0,0,0,0,0,0,0,0,0,14,255,247,0,0,0,0,0,191,255,255,255,255,255,255,255,255,255,176,0,0,0,12,
255,255,255,255,255,255,255,255,255,251,0,0,0,0,223,255,255,255,255,255,255,255,255,255,176,0,0,0,14,255,254,238,
238,238,238,238,238,238,234,0,0,0,0,255,255,128,0,0,0,0,0,0,0,0,0,0,0,31,255,247,0,0,0,0,
0,0,0,0,0,0,0,2,255,255,96,0,0,0,0,0,0,0,0,0,0,0,63,255,245,0,0,0,0,0,0,0,
0,0,0,0,4,255,255,64,0,0,0,0,0,0,0,0,0,0,0,95,255,243,0,0,0,0,0,0,0,0,0,0,
0,6,255,255,32,0,0,0,0,0,0,0,0,0,0,0,127,255,241,0,0,0,0,0,0,0,0,0,0,0,8,255,
255,0,0,0,0,0,0,0,0,0,0,0,0,159,255,224,3,140,238,254,218,97,0,0,0,0,0,10,255,253,60,255,
255,255,255,255,231,0,0,0,0,0,175,255,239,255,255,255,255,255,255,251,16,0,0,0,11,255,255,255,255,236,205,255,
255,255,252,16,0,0,0,207,255,255,232,48,0,1,109,255,255,250,0,0,0,13,255,255,161,0,0,0,0,10,255,255,
245,0,0,0,85,85,64,0,0,0,0,0,10,255,255,192,0,0,0,0,0,0,0,0,0,0,0,30,255,255,32,0,
0,0,0,0,0,0,0,0,0,0,159,255,247,0,0,0,0,0,0,0,0,0,0,0,5,255,255,144,0,0,0,0,
0,0,0,0,0,0,0,47,255,250,0,0,0,0,0,0,0,0,0,0,0,1,255,255,176,0,0,0,0,0,0,0,
0,0,0,0,47,255,250,0,0,0,0,0,0,0,0,0,0,0,3,255,255,144,0,0,0,0,0,0,0,0,0,0,
0,127,255,248,0,0,139,206,208,0,0,0,0,0,0,11,255,255,64,0,10,255,255,80,0,0,0,0,0,3,255,255,
224,0,0,111,255,253,16,0,0,0,0,0,207,255,248,0,0,0,223,255,252,16,0,0,0,1,191,255,254,16,0,0,
5,255,255,254,114,0,0,23,223,255,255,80,0,0,0,8,255,255,255,253,204,223,255,255,255,128,0,0,0,0,7,255,
255,255,255,255,255,255,254,96,0,0,0,0,0,3,191,255,255,255,255,255,250,48,0,0,0,0,0,0,0,39,173,239,
254,218,114,0,0,0,0,0,0,0,0,0,0,22,173,239,237,183,16,0,0,0,0,0,0,0,0,126,255,255,255,255,
254,129,0,0,0,0,0,0,1,191,255,255,255,255,255,255,193,0,0,0,0,0,1,191,255,255,237,188,255,255,255,176,
0,0,0,0,0,159,255,254,113,0,1,126,255,255,112,0,0,0,0,95,255,253,48,0,0,0,78,255,254,16,0,0,
0,12,255,254,48,0,0,0,0,127,255,246,0,0,0,5,255,255,112,0,0,0,0,1,237,184,64,0,0,0,191,255,
225,0,0,0,0,0,0,0,0,0,0,0,31,255,248,0,0,0,0,0,0,0,0,0,0,0,5,255,255,64,0,0,
0,0,0,0,0,0,0,0,0,159,255,224,0,0,0,0,0,0,0,0,0,0,0,12,255,251,0,0,0,0,0,0,
0,0,0,0,0,0,239,255,144,0,0,0,0,0,0,0,0,0,0,0,31,255,247,0,3,140,239,237,183,48,0,0,
0,0,3,255,255,96,42,255,255,255,255,255,146,0,0,0,0,79,255,245,62,255,255,255,255,255,255,211,0,0,0,5,
255,255,110,255,253,169,171,239,255,255,226,0,0,0,111,255,253,255,196,0,0,1,142,255,255,176,0,0,6,255,255,255,
160,0,0,0,0,78,255,255,80,0,0,111,255,255,192,0,0,0,0,0,111,255,252,0,0,6,255,255,245,0,0,0,
0,0,0,223,255,242,0,0,95,255,254,0,0,0,0,0,0,8,255,255,96,0,4,255,255,192,0,0,0,0,0,0,
79,255,248,0,0,47,255,251,0,0,0,0,0,0,2,255,255,144,0,0,255,255,176,0,0,0,0,0,0,31,255,250,
0,0,12,255,252,0,0,0,0,0,0,1,255,255,144,0,0,175,255,224,0,0,0,0,0,0,63,255,248,0,0,6,
255,255,48,0,0,0,0,0,5,255,255,112,0,0,31,255,249,0,0,0,0,0,0,159,255,243,0,0,0,191,255,226,
0,0,0,0,0,30,255,254,0,0,0,4,255,255,160,0,0,0,0,9,255,255,144,0,0,0,11,255,255,128,0,0,
0,6,255,255,242,0,0,0,0,46,255,255,179,0,0,58,255,255,247,0,0,0,0,0,95,255,255,253,204,223,255,255,
251,0,0,0,0,0,0,94,255,255,255,255,255,255,250,0,0,0,0,0,0,0,59,255,255,255,255,255,214,0,0,0,
0,0,0,0,0,3,140,239,254,201,80,0,0,0,0,0,111,255,255,255,255,255,255,255,255,255,255,255,96,0,6,255,
255,255,255,255,255,255,255,255,255,255,246,0,0,111,255,255,255,255,255,255,255,255,255,255,255,96,0,5,238,238,238,238,
238,238,238,238,238,239,255,245,0,0,0,0,0,0,0,0,0,0,0,9,255,252,0,0,0,0,0,0,0,0,0,0,
0,4,255,255,64,0,0,0,0,0,0,0,0,0,0,0,207,255,144,0,0,0,0,0,0,0,0,0,0,0,143,255,
209,0,0,0,0,0,0,0,0,0,0,0,63,255,245,0,0,0,0,0,0,0,0,0,0,0,12,255,251,0,0,0,
0,0,0,0,0,0,0,0,6,255,254,48,0,0,0,0,0,0,0,0,0,0,1,223,255,128,0,0,0,0,0,0,
0,0,0,0,0,143,255,225,0,0,0,0,0,0,0,0,0,0,0,47,255,246,0,0,0,0,0,0,0,0,0,0,
0,10,255,252,0,0,0,0,0,0,0,0,0,0,0,3,255,255,80,0,0,0,0,0,0,0,0,0,0,0,175,255,
192,0,0,0,0,0,0,0,0,0,0,0,63,255,246,0,0,0,0,0,0,0,0,0,0,0,9,255,253,0,0,0,
0,0,0,0,0,0,0,0,1,239,255,112,0,0,0,0,0,0,0,0,0,0,0,127,255,242,0,0,0,0,0,0,
0,0,0,0,0,13,255,251,0,0,0,0,0,0,0,0,0,0,0,3,255,255,96,0,0,0,0,0,0,0,0,0,
0,0,159,255,225,0,0,0,0,0,0,0,0,0,0,0,13,255,251,0,0,0,0,0,0,0,0,0,0,0,3,255,
255,112,0,0,0,0,0,0,0,0,0,0,0,127,255,243,0,0,0,0,0,0,0,0,0,0,0,11,255,254,0,0,
0,0,0,0,0,0,0,0,0,0,239,255,176,0,0,0,0,0,0,0,0,0,0,0,47,255,249,0,0,0,0,0,
0,0,0,0,0,0,5,255,255,112,0,0,0,0,0,0,0,0,0,0,0,127,255,245,0,0,0,0,0,0,0,0,
0,0,0,9,255,255,64,0,0,0,0,0,0,0,0,0,0,0,175,255,243,0,0,0,0,0,0,0,0,0,0,0,
11,255,255,32,0,0,0,0,0,0,0,0,0,0,0,191,255,241,0,0,0,0,0,0,0,0,0,0,0,5,156,222,
254,219,132,0,0,0,0,0,0,0,0,109,255,255,255,255,255,252,80,0,0,0,0,0,1,175,255,255,255,255,255,255,
255,160,0,0,0,0,1,191,255,255,218,135,138,223,255,255,160,0,0,0,0,159,255,253,80,0,0,0,110,255,255,112,
0,0,0,47,255,254,32,0,0,0,0,79,255,254,16,0,0,8,255,255,112,0,0,0,0,0,159,255,246,0,0,0,
191,255,241,0,0,0,0,0,4,255,255,144,0,0,13,255,253,0,0,0,0,0,0,31,255,251,0,0,0,239,255,192,
0,0,0,0,0,0,255,255,192,0,0,13,255,253,0,0,0,0,0,0,31,255,251,0,0,0,175,255,225,0,0,0,
0,0,3,255,255,128,0,0,6,255,255,80,0,0,0,0,0,127,255,244,0,0,0,30,255,252,16,0,0,0,0,29,
255,253,0,0,0,0,111,255,251,16,0,0,0,27,255,255,64,0,0,0,0,159,255,254,132,16,36,142,255,255,112,0,
0,0,0,0,126,255,255,255,255,255,255,254,80,0,0,0,0,0,0,40,239,255,255,255,255,214,16,0,0,0,0,0,
0,58,239,255,255,255,255,255,234,48,0,0,0,0,0,110,255,255,218,135,138,223,255,255,112,0,0,0,0,127,255,253,
80,0,0,0,93,255,255,112,0,0,0,63,255,252,16,0,0,0,0,29,255,255,64,0,0,12,255,254,32,0,0,0,
0,0,47,255,251,0,0,3,255,255,144,0,0,0,0,0,0,175,255,243,0,0,127,255,245,0,0,0,0,0,0,6,
255,255,112,0,10,255,255,32,0,0,0,0,0,0,63,255,249,0,0,191,255,240,0,0,0,0,0,0,2,255,255,160,
0,11,255,255,16,0,0,0,0,0,0,63,255,250,0,0,175,255,242,0,0,0,0,0,0,4,255,255,144,0,9,255,
255,96,0,0,0,0,0,0,127,255,247,0,0,95,255,250,0,0,0,0,0,0,11,255,255,48,0,1,239,255,242,0,
0,0,0,0,3,255,255,208,0,0,8,255,255,193,0,0,0,0,1,207,255,247,0,0,0,29,255,255,213,0,0,0,
4,223,255,253,0,0,0,0,62,255,255,253,168,120,173,255,255,254,32,0,0,0,0,61,255,255,255,255,255,255,255,252,
48,0,0,0,0,0,24,239,255,255,255,255,255,232,16,0,0,0,0,0,0,1,89,205,239,237,201,81,0,0,0,0,
0,0,0,0,4,139,222,254,218,80,0,0,0,0,0,0,0,0,75,255,255,255,255,255,213,0,0,0,0,0,0,0,
127,255,255,255,255,255,255,249,0,0,0,0,0,0,159,255,255,254,204,223,255,255,249,0,0,0,0,0,95,255,255,196,
0,0,58,255,255,246,0,0,0,0,30,255,255,144,0,0,0,7,255,255,225,0,0,0,7,255,255,176,0,0,0,0,
9,255,255,112,0,0,0,223,255,243,0,0,0,0,0,29,255,253,0,0,0,47,255,251,0,0,0,0,0,0,143,255,
244,0,0,5,255,255,112,0,0,0,0,0,2,255,255,128,0,0,127,255,244,0,0,0,0,0,0,13,255,251,0,0,
8,255,255,48,0,0,0,0,0,0,191,255,224,0,0,159,255,242,0,0,0,0,0,0,10,255,255,32,0,8,255,255,
48,0,0,0,0,0,0,159,255,244,0,0,127,255,244,0,0,0,0,0,0,10,255,255,80,0,6,255,255,112,0,0,
0,0,0,0,191,255,246,0,0,47,255,251,0,0,0,0,0,0,30,255,255,112,0,0,223,255,242,0,0,0,0,0,
7,255,255,247,0,0,8,255,255,176,0,0,0,0,3,239,255,255,128,0,0,46,255,255,128,0,0,0,3,223,255,255,
247,0,0,0,127,255,255,163,0,0,23,239,251,255,255,112,0,0,0,191,255,255,253,186,207,255,253,79,255,246,0,0,
0,1,191,255,255,255,255,255,253,52,255,255,80,0,0,0,0,126,255,255,255,255,249,16,95,255,243,0,0,0,0,0,
39,189,239,235,130,0,8,255,255,16,0,0,0,0,0,0,0,0,0,0,0,175,255,208,0,0,0,0,0,0,0,0,
0,0,0,12,255,250,0,0,0,0,0,0,0,0,0,0,0,2,255,255,112,0,0,0,0,0,0,0,0,0,0,0,
127,255,242,0,0,0,0,0,16,0,0,0,0,0,13,255,252,0,0,0,7,189,252,0,0,0,0,0,5,255,255,96,
0,0,0,143,255,245,0,0,0,0,2,239,255,208,0,0,0,3,255,255,227,0,0,0,2,207,255,245,0,0,0,0,
10,255,255,230,16,0,22,223,255,250,0,0,0,0,0,45,255,255,254,203,206,255,255,252,16,0,0,0,0,0,62,255,
255,255,255,255,255,251,16,0,0,0,0,0,0,42,255,255,255,255,255,231,0,0,0,0,0,0,0,0,3,139,222,254,
218,97,0,0,0,0,0,0,0,95,255,251,0,0,0,0,95,255,251,0,0,0,0,95,255,251,0,0,0,0,95,255,
251,0,0,0,0,95,255,251,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,95,255,251,0,0,0,0,95,255,251,0,0,0,0,95,255,251,0,0,0,0,95,255,251,0,0,0,0,95,
255,251,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,4,68,68,66,0,0,0,0,0,0,0,0,95,255,255,254,48,0,0,0,0,0,0,0,111,168,136,159,210,0,0,
0,0,0,0,0,111,80,0,8,253,204,204,204,204,179,0,0,111,96,16,0,158,255,255,255,255,248,0,0,111,96,0,
0,1,17,17,17,21,248,0,0,111,96,0,0,0,0,0,0,4,248,0,0,111,96,0,0,0,0,0,0,4,248,0,
0,111,96,0,0,0,0,0,0,4,248,0,0,111,96,0,0,0,0,0,0,4,248,0,0,111,96,0,0,0,0,0,
0,4,248,0,0,111,96,16,0,0,0,0,1,4,248,0,0,111,80,0,0,0,0,0,0,3,248,0,0,111,150,102,
102,102,102,102,102,104,248,0,0,143,255,255,255,255,255,255,255,255,247,0,0,39,102,102,102,102,102,102,102,102,97,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,25,170,170,170,170,168,
16,0,0,0,0,0,0,0,0,0,0,0,0,0,159,255,255,255,255,255,176,0,0,0,0,0,0,0,0,0,0,0,
0,0,207,255,255,255,255,255,249,1,0,0,0,0,0,0,0,0,0,0,0,0,191,249,102,102,102,159,255,112,0,0,
0,0,0,0,0,0,0,0,0,0,191,244,0,0,0,9,255,248,102,102,102,102,102,102,102,80,0,0,0,0,191,245,
1,0,0,0,191,255,255,255,255,255,255,255,255,247,0,0,0,0,191,244,0,0,0,0,28,255,255,255,255,255,255,255,
255,252,0,0,0,0,191,244,0,0,0,0,1,138,170,170,170,170,170,170,191,251,0,0,0,0,191,244,0,0,0,0,
0,0,0,0,0,0,0,0,79,251,0,0,0,0,191,244,0,0,0,0,0,0,0,0,0,0,0,16,95,251,0,0,
0,0,191,244,0,0,0,0,0,0,0,0,0,0,0,0,79,251,0,0,0,0,191,244,0,0,0,0,0,0,0,0,
0,0,0,0,79,251,0,0,0,0,191,244,0,0,0,0,0,0,0,0,0,0,0,0,79,251,0,0,0,0,191,244,
0,0,0,0,0,0,0,0,0,0,0,0,79,251,0,0,0,0,191,244,0,0,0,0,0,0,0,0,0,0,0,0,
79,251,0,0,0,0,191,244,0,0,0,0,0,0,0,0,0,0,0,0,79,251,0,0,0,0,191,244,0,0,0,0,
0,0,0,0,0,0,0,0,79,251,0,0,0,0,191,244,0,0,0,0,0,0,0,0,0,0,0,0,79,251,0,0,
0,0,191,244,0,0,0,0,0,0,0,0,0,0,0,0,79,251,0,0,0,0,191,245,0,0,0,0,0,0,0,0,
0,0,0,0,95,251,0,0,0,0,191,244,0,0,0,0,0,0,0,0,0,0,0,0,79,251,0,0,0,0,191,245,
18,17,17,17,17,17,17,17,17,17,17,33,95,251,0,0,0,0,191,254,238,238,238,238,238,238,238,238,238,238,238,238,
239,252,0,0,0,0,207,255,255,255,255,255,255,255,255,255,255,255,255,255,255,251,0,0,0,0,111,238,238,238,238,238,
238,238,238,238,238,238,238,238,238,212,0,0,0,0,2,33,17,17,17,17,17,17,17,17,17,17,17,17,17,16,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
17,17,17,17,16,0,0,0,0,0,0,125,255,255,255,255,232,0,0,0,0,0,4,254,203,187,187,188,239,96,0,0,
0,0,8,245,4,68,68,64,63,160,0,0,0,0,8,243,127,255,255,249,31,160,0,0,0,0,8,243,175,239,255,251,
47,160,0,0,0,0,8,243,143,255,255,250,47,160,0,0,0,0,8,244,22,102,102,98,47,160,0,0,0,0,8,244,
0,0,0,0,63,160,0,0,0,0,8,244,71,21,97,116,47,160,0,0,0,0,8,244,207,78,245,253,47,160,0,0,
0,0,8,244,89,23,129,149,47,160,0,0,0,0,8,244,0,0,0,0,63,160,0,0,0,0,8,244,71,5,96,116,
47,160,0,0,0,0,8,244,223,79,245,253,47,160,0,0,0,0,8,244,71,22,113,117,47,160,0,0,0,0,8,244,
72,6,112,132,47,160,0,0,0,0,5,253,239,191,252,254,207,96,0,0,0,0,0,143,255,255,255,255,249,0,0,0,
0,0,0,2,51,51,51,51,32,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,1,17,17,17,17,17,
17,16,0,0,0,0,0,0,0,0,0,0,0,8,222,238,238,238,238,238,238,237,145,0,0,0,0,0,0,0,0,0,
0,191,255,255,255,255,255,255,255,255,252,16,0,0,0,0,0,0,0,0,7,255,254,238,238,238,238,238,238,239,255,144,
0,0,0,0,0,0,0,0,12,255,130,16,0,0,0,0,1,23,255,209,0,0,0,0,0,0,0,0,13,255,32,22,
102,102,102,102,97,1,239,225,0,0,0,0,0,0,0,0,13,255,48,191,255,255,255,255,252,17,239,225,0,0,0,0,
0,0,0,0,13,255,49,255,255,255,255,255,255,49,239,225,0,0,0,0,0,0,0,0,13,255,49,239,255,255,255,255,
255,33,239,225,0,0,0,0,0,0,0,0,13,255,49,255,255,255,255,255,255,49,239,225,0,0,0,0,0,0,0,0,
13,255,48,207,255,255,255,255,253,17,239,225,0,0,0,0,0,0,0,0,13,255,48,39,136,136,136,136,130,1,239,225,
0,0,0,0,0,0,0,0,13,255,48,0,0,0,0,0,0,1,239,225,0,0,0,0,0,0,0,0,13,255,48,17,
16,17,17,1,17,1,239,225,0,0,0,0,0,0,0,0,13,255,48,0,0,0,0,0,0,1,239,225,0,0,0,0,
0,0,0,0,13,255,48,139,80,42,162,4,184,1,239,225,0,0,0,0,0,0,0,0,13,255,37,255,241,175,250,14,
255,80,239,225,0,0,0,0,0,0,0,0,13,255,37,255,241,175,250,14,255,80,239,225,0,0,0,0,0,0,0,0,
13,255,48,139,80,42,162,4,184,1,239,225,0,0,0,0,0,0,0,0,13,255,48,0,0,0,0,0,0,1,239,225,
0,0,0,0,0,0,0,0,13,255,48,16,0,0,0,0,0,1,239,225,0,0,0,0,0,0,0,0,13,255,48,1,
0,1,16,0,16,1,239,225,0,0,0,0,0,0,0,0,13,255,49,190,128,77,212,7,235,17,239,225,0,0,0,0,
0,0,0,0,13,255,37,255,242,191,252,15,255,96,239,225,0,0,0,0,0,0,0,0,13,255,35,239,193,127,248,11,
254,49,239,225,0,0,0,0,0,0,0,0,13,255,48,37,16,4,64,1,83,2,239,225,0,0,0,0,0,0,0,0,
13,255,32,37,16,4,64,0,82,1,239,225,0,0,0,0,0,0,0,0,12,255,114,239,192,127,248,11,254,37,255,209,
0,0,0,0,0,0,0,0,8,255,254,255,253,255,255,223,255,239,255,144,0,0,0,0,0,0,0,0,1,207,255,255,
255,255,255,255,255,255,253,32,0,0,0,0,0,0,0,0,0,26,239,255,255,255,255,255,255,254,162,0,0,0,0,0,
0,0,0,0,0,0,19,51,51,51,51,51,51,50,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,23,136,136,136,136,114,0,0,0,0,0,1,207,255,255,255,255,253,32,0,0,
0,0,7,249,68,68,68,68,143,144,0,0,0,0,8,244,0,0,0,0,47,160,0,0,0,0,8,244,0,0,0,0,
47,160,0,0,0,0,8,246,204,204,204,204,95,160,0,0,0,0,8,246,206,238,238,237,95,160,0,0,0,0,8,244,
0,0,0,0,47,160,0,0,0,0,8,245,84,68,68,69,63,160,0,0,0,0,8,247,255,255,255,255,111,160,0,0,
0,0,8,244,86,102,102,101,63,160,0,0,0,0,8,244,0,0,0,0,47,160,0,0,0,0,8,246,204,204,215,0,
63,160,0,0,0,0,8,246,206,238,231,0,63,160,0,0,0,0,8,243,0,0,0,0,47,160,0,0,0,0,7,248,
51,51,51,51,127,144,0,0,0,0,2,223,255,255,255,255,254,48,0,0,0,0,0,40,170,170,170,170,147,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,19,51,51,51,51,51,51,50,0,0,0,0,0,0,0,0,0,0,
0,26,239,255,255,255,255,255,255,254,162,0,0,0,0,0,0,0,0,0,1,207,255,255,255,255,255,255,255,255,253,32,
0,0,0,0,0,0,0,0,8,255,253,221,221,221,221,221,221,223,255,160,0,0,0,0,0,0,0,0,12,255,112,0,
0,0,0,0,0,5,255,225,0,0,0,0,0,0,0,0,13,255,32,0,0,0,0,0,0,1,239,225,0,0,0,0,
0,0,0,0,13,255,48,16,0,0,0,0,0,1,239,225,0,0,0,0,0,0,0,0,13,255,48,0,0,0,0,0,
0,1,239,225,0,0,0,0,0,0,0,0,13,255,34,100,68,68,68,68,70,49,239,225,0,0,0,0,0,0,0,0,
13,255,60,255,255,255,255,255,255,227,239,225,0,0,0,0,0,0,0,0,13,255,60,255,255,255,255,255,255,227,239,225,
0,0,0,0,0,0,0,0,13,255,34,102,102,102,102,102,102,49,239,225,0,0,0,0,0,0,0,0,13,255,48,0,
0,0,0,0,0,1,239,225,0,0,0,0,0,0,0,0,13,255,48,0,0,0,0,0,0,1,239,225,0,0,0,0,
0,0,0,0,13,255,35,136,136,136,136,136,136,65,239,225,0,0,0,0,0,0,0,0,13,255,61,255,255,255,255,255,
255,243,239,225,0,0,0,0,0,0,0,0,13,255,59,255,255,255,255,255,255,210,239,225,0,0,0,0,0,0,0,0,
13,255,33,67,51,51,51,51,52,17,239,225,0,0,0,0,0,0,0,0,13,255,48,0,0,0,0,0,0,1,239,225,
0,0,0,0,0,0,0,0,13,255,48,0,0,0,0,0,0,1,239,225,0,0,0,0,0,0,0,0,13,255,38,186,
170,170,171,64,0,1,239,225,0,0,0,0,0,0,0,0,13,255,78,255,255,255,255,192,0,1,239,225,0,0,0,0,
0,0,0,0,13,255,58,254,238,238,238,112,0,1,239,225,0,0,0,0,0,0,0,0,13,255,48,33,17,17,34,0,
0,1,239,225,0,0,0,0,0,0,0,0,13,255,32,0,0,0,0,0,0,1,239,225,0,0,0,0,0,0,0,0,
12,255,96,0,0,0,0,0,0,4,255,225,0,0,0,0,0,0,0,0,9,255,252,203,187,187,187,187,188,206,255,160,
0,0,0,0,0,0,0,0,1,223,255,255,255,255,255,255,255,255,254,32,0,0,0,0,0,0,0,0,0,59,255,255,
255,255,255,255,255,255,195,0,0,0,0,0,0,0,0,0,0,0,52,68,68,68,68,68,68,67,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,10,160,0,10,160,0,10,160,0,0,0,0,13,224,0,13,224,0,13,224,0,0,
0,0,12,224,0,12,208,0,12,224,0,0,0,0,12,224,1,158,250,32,12,224,0,0,0,0,12,224,8,255,255,160,
12,224,0,0,0,0,12,224,9,255,255,176,12,224,0,0,0,0,12,224,2,191,251,48,12,224,0,0,0,0,12,224,
0,12,224,0,12,224,0,0,0,0,12,224,0,12,224,1,158,250,32,0,0,0,12,224,0,12,224,8,255,255,160,0,
0,1,158,250,32,12,224,9,255,255,176,0,0,8,255,255,160,12,224,2,191,251,48,0,0,9,255,255,176,12,224,0,
12,224,0,0,0,2,191,251,48,12,224,0,12,224,0,0,0,0,12,224,0,12,224,0,12,224,0,0,0,0,12,224,
0,12,224,0,12,224,0,0,0,0,13,224,0,13,224,0,13,224,0,0,0,0,10,160,0,10,160,0,10,160,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,26,161,0,0,0,26,161,0,0,0,26,161,0,0,0,0,0,0,0,0,
111,246,0,0,0,111,246,0,0,0,111,246,0,0,0,0,0,0,0,0,95,246,0,0,0,95,246,0,0,0,95,246,
0,0,0,0,0,0,0,0,79,246,0,0,0,95,246,0,0,0,79,246,0,0,0,0,0,0,0,0,79,246,0,0,
0,79,246,0,0,0,79,246,0,0,0,0,0,0,0,0,79,246,0,0,23,191,252,113,0,0,79,246,0,0,0,0,
0,0,0,0,79,246,0,0,191,255,255,252,16,0,79,246,0,0,0,0,0,0,0,0,79,246,1,5,255,255,255,255,
96,16,79,246,0,0,0,0,0,0,0,0,79,246,1,7,255,255,255,255,128,16,79,246,0,0,0,0,0,0,0,0,
79,246,1,4,255,255,255,255,96,16,79,246,0,0,0,0,0,0,0,0,79,246,0,0,175,255,255,251,0,0,79,246,
0,0,0,0,0,0,0,0,79,246,0,0,5,175,251,96,0,0,95,246,0,0,0,0,0,0,0,0,79,246,0,0,
0,79,246,0,0,0,79,246,1,0,0,0,0,0,0,0,79,246,0,0,0,95,246,0,0,3,159,250,64,0,0,0,
0,0,0,0,95,246,0,0,0,79,246,0,0,143,255,255,250,0,0,0,0,0,0,0,79,246,1,0,0,79,246,1,
3,255,255,255,255,80,0,0,0,0,0,0,95,247,0,0,0,79,246,1,7,255,255,255,255,128,0,0,0,0,0,76,
239,254,197,0,0,79,246,1,5,255,255,255,255,112,0,0,0,0,2,239,255,255,255,48,0,79,246,0,1,207,255,255,
253,16,0,0,0,0,6,255,255,255,255,128,16,79,246,0,0,25,207,253,146,0,0,0,0,0,6,255,255,255,255,128,
16,79,246,0,0,0,79,246,0,0,0,0,0,0,2,255,255,255,255,48,0,79,246,0,0,0,95,246,0,0,0,0,
0,0,0,93,255,255,230,0,0,79,246,0,0,0,79,246,0,0,0,0,0,0,0,1,111,248,16,0,0,79,246,0,
0,0,79,246,0,0,0,0,0,0,0,16,79,246,1,0,0,79,246,0,0,0,79,246,0,0,0,0,0,0,0,0,
95,246,0,0,0,79,246,0,0,0,79,246,0,0,0,0,0,0,0,0,79,246,0,0,0,79,246,0,0,0,79,246,
0,0,0,0,0,0,0,0,95,246,0,0,0,95,246,0,0,0,95,246,0,0,0,0,0,0,0,0,111,246,0,0,
0,111,246,0,0,0,111,246,0,0,0,0,0,0,0,0,26,161,0,0,0,26,161,0,0,0,26,161,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,56,189,219,131,0,0,0,0,0,0,0,26,255,254,239,255,161,0,0,0,
0,0,3,223,197,32,2,92,253,48,0,0,0,0,29,248,0,7,128,0,143,209,0,0,0,0,175,128,16,79,246,1,
8,250,0,0,0,3,252,0,0,44,211,0,0,207,48,0,0,8,245,9,112,0,16,7,144,95,128,0,0,12,240,111,
244,0,0,79,246,15,192,0,0,13,224,61,194,0,0,44,211,14,208,0,0,13,208,1,0,0,0,0,16,13,208,0,
0,12,241,0,0,0,0,0,0,31,192,0,0,8,245,0,124,80,5,199,0,95,128,0,0,3,252,0,239,192,12,254,
0,207,48,0,0,0,175,128,91,64,4,181,8,250,0,0,0,0,29,248,0,0,0,0,143,209,0,0,0,0,3,223,
197,32,2,92,253,48,0,0,0,0,0,26,255,253,223,255,161,0,0,0,0,0,0,0,56,189,219,131,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,2,89,171,186,149,32,0,0,0,0,0,0,0,0,0,0,0,
0,0,5,174,255,255,255,255,234,80,0,0,0,0,0,0,0,0,0,0,0,2,175,255,255,255,255,255,255,250,32,0,
0,0,0,0,0,0,0,0,0,94,255,255,200,101,86,140,255,255,229,0,0,0,0,0,0,0,0,0,6,255,255,163,
0,0,0,0,58,255,255,96,0,0,0,0,0,0,0,0,95,255,212,0,0,4,64,0,0,77,255,245,0,0,0,0,
0,0,0,2,239,252,32,0,0,143,248,0,0,2,207,254,32,0,0,0,0,0,0,11,255,210,0,0,2,255,255,32,
0,0,45,255,176,0,0,0,0,0,0,79,255,64,16,0,2,239,254,32,0,1,4,255,244,0,0,0,0,0,0,191,
250,1,0,0,0,109,214,0,0,0,16,175,251,0,0,0,0,0,2,239,243,0,86,16,0,1,16,0,1,101,0,63,
254,32,0,0,0,0,5,255,192,8,255,193,0,0,0,0,28,255,128,12,255,80,0,0,0,0,9,255,128,30,254,246,
0,0,0,0,111,239,225,8,255,144,0,0,0,0,11,255,96,29,255,244,0,0,0,0,79,255,209,6,255,176,0,0,
0,0,12,255,64,3,189,112,0,0,0,0,7,219,48,4,255,192,0,0,0,0,12,255,64,0,0,0,0,0,0,0,
0,0,0,4,255,192,0,0,0,0,11,255,96,0,0,0,0,0,0,0,0,0,0,6,255,176,0,0,0,0,9,255,
128,0,0,0,0,0,0,0,0,0,0,8,255,144,0,0,0,0,5,255,192,0,0,22,64,0,0,4,97,0,0,12,
255,80,0,0,0,0,2,239,243,0,1,207,246,0,0,111,252,16,0,63,254,32,0,0,0,0,0,191,250,1,6,254,
253,0,0,223,239,96,16,175,251,0,0,0,0,0,0,79,255,64,5,255,252,0,0,207,255,80,4,255,244,0,0,0,
0,0,0,11,255,210,0,142,195,0,0,60,232,0,45,255,176,0,0,0,0,0,0,2,239,252,32,1,0,0,0,0,
16,2,207,254,32,0,0,0,0,0,0,0,95,255,212,0,1,0,0,16,0,77,255,245,0,0,0,0,0,0,0,0,
6,255,255,163,0,0,0,0,58,255,255,96,0,0,0,0,0,0,0,0,0,94,255,255,200,100,70,140,255,255,229,0,
0,0,0,0,0,0,0,0,0,2,175,255,255,255,255,255,255,250,32,0,0,0,0,0,0,0,0,0,0,0,5,174,
255,255,255,255,234,80,0,0,0,0,0,0,0,0,0,0,0,0,0,2,89,171,186,149,32,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,51,51,0,0,0,0,0,0,0,0,0,
1,239,254,16,0,0,0,0,0,0,1,64,2,239,254,32,4,16,0,0,0,0,28,244,0,239,254,0,79,193,0,0,
0,2,207,254,86,255,255,101,239,252,32,0,0,4,255,255,255,253,223,255,255,255,64,0,0,0,78,255,249,48,3,159,
255,228,0,0,0,0,5,255,96,1,16,6,255,80,0,0,0,18,22,249,1,158,233,16,159,97,33,0,3,238,239,243,
9,251,191,144,63,254,238,48,3,255,255,208,31,176,11,241,13,255,255,48,3,255,255,208,31,176,11,241,13,255,255,48,
3,238,239,243,9,251,191,144,63,254,238,48,0,18,22,249,1,158,233,16,159,97,33,0,0,0,5,255,96,1,16,6,
255,80,0,0,0,0,78,255,249,48,3,159,255,228,0,0,0,4,255,255,255,253,223,255,255,255,64,0,0,2,207,254,
86,255,255,101,239,252,32,0,0,0,28,244,0,239,254,0,79,193,0,0,0,0,1,64,2,239,254,32,4,16,0,0,
0,0,0,0,1,239,254,16,0,0,0,0,0,0,0,0,0,51,51,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,77,221,221,212,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,95,255,255,245,
0,0,0,0,0,0,0,0,0,0,0,0,0,16,0,0,79,255,255,244,0,0,1,0,0,0,0,0,0,0,0,0,
8,211,0,0,79,255,255,244,0,0,61,128,0,0,0,0,0,0,0,0,127,254,48,16,95,255,255,245,1,3,239,247,
0,0,0,0,0,0,0,7,255,255,227,0,79,255,255,244,0,62,255,255,112,0,0,0,0,0,0,143,255,255,254,71,
207,255,255,252,116,239,255,255,248,0,0,0,0,0,2,239,255,255,255,255,255,255,255,255,255,255,255,255,254,32,0,0,
0,0,0,62,255,255,255,255,253,168,138,223,255,255,255,255,227,0,0,0,0,0,0,3,239,255,255,252,81,0,0,4,
191,255,255,254,48,0,0,0,0,0,0,0,62,255,255,144,0,16,1,0,8,255,255,227,0,0,0,0,0,0,0,1,
4,255,249,0,16,0,0,0,0,143,255,64,16,0,0,0,0,0,0,0,7,255,192,0,4,172,202,64,0,11,255,112,
0,0,0,0,0,4,68,69,77,255,80,16,111,255,255,246,0,3,255,212,84,68,64,0,0,13,255,255,255,253,0,3,
255,252,207,255,48,0,207,255,255,255,208,0,0,13,255,255,255,250,1,10,255,96,6,255,160,16,143,255,255,255,208,0,
0,13,255,255,255,248,0,13,252,0,0,207,208,0,111,255,255,255,208,0,0,13,255,255,255,248,0,13,252,0,0,207,
208,0,111,255,255,255,208,0,0,13,255,255,255,250,1,10,255,96,6,255,160,16,143,255,255,255,208,0,0,13,255,255,
255,253,0,3,255,252,207,255,48,0,191,255,255,255,208,0,0,4,68,69,77,255,64,0,111,255,255,246,0,2,255,212,
84,68,64,0,0,0,0,0,7,255,192,0,4,172,202,64,0,10,255,112,0,0,0,0,0,0,0,1,4,255,248,0,
0,0,0,0,0,111,255,64,16,0,0,0,0,0,0,0,62,255,255,128,0,16,1,0,6,255,255,227,0,0,0,0,
0,0,0,3,239,255,255,251,48,0,0,3,175,255,255,254,48,0,0,0,0,0,0,62,255,255,255,255,252,134,104,191,
255,255,255,255,227,0,0,0,0,0,2,239,255,255,255,255,255,255,255,255,255,255,255,255,254,32,0,0,0,0,0,143,
255,255,254,71,207,255,255,252,116,239,255,255,248,0,0,0,0,0,0,7,255,255,227,0,79,255,255,244,0,62,255,255,
112,0,0,0,0,0,0,0,127,254,48,16,95,255,255,245,1,3,239,247,0,0,0,0,0,0,0,0,8,211,0,0,
79,255,255,244,0,0,61,128,0,0,0,0,0,0,0,0,0,16,0,0,79,255,255,244,0,0,1,0,0,0,0,0,
0,0,0,0,0,0,0,0,95,255,255,245,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,77,221,221,212,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,0,0,0,0,0,0,0,0,0,0,5,173,237,182,16,0,0,93,253,168,172,254,96,0,79,179,0,0,2,
175,80,1,80,58,239,235,64,81,0,0,95,232,104,223,112,0,0,2,112,19,16,99,0,0,0,0,127,255,112,0,0,
0,0,3,190,179,0,0,0,0,0,10,250,0,0,0,0,0,0,58,48,0,0,0,0,0,0,0,0,0,0,1,131,
0,0,28,247,39,16,175,128,95,184,250,0,6,255,192,0,0,122,16,0,0,0,0,0,37,0,0,95,96,0,8,244,
0,0,175,48,0,11,210,0,11,226,0,175,64,8,245,0,95,96,0,37,0,0,0,0,0,0,82,0,6,245,0,79,
128,3,250,0,45,176,0,46,176,0,4,250,0,0,95,128,0,6,245,0,0,82,0,0,104,0,0,0,134,143,128,0,
8,248,8,249,0,159,128,0,159,136,249,0,0,8,255,128,0,0,8,255,128,0,0,159,136,249,0,8,249,0,159,128,
143,128,0,8,248,104,0,0,0,134,0,0,0,0,0,0,0,0,0,0,0,0,0,3,163,0,0,0,0,0,143,245,
0,0,0,0,60,251,244,0,0,0,7,253,51,244,0,0,3,207,145,5,244,0,0,110,196,0,4,244,0,0,127,178,
0,4,244,0,0,5,239,112,5,244,0,0,0,25,252,35,244,0,0,0,0,94,250,244,0,0,0,0,1,159,245,0,
0,0,0,0,5,178,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,17,0,0,0,0,0,
92,255,198,0,0,0,8,253,153,223,144,0,0,95,144,0,7,246,0,0,205,0,0,0,206,0,1,249,0,0,0,127,
32,1,248,0,0,0,111,32,0,221,0,0,0,190,0,0,111,112,0,6,248,0,0,9,252,119,191,176,0,0,0,125,
255,232,0,0,0,0,0,34,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,
0,0,0,42,204,204,204,179,0,0,175,204,204,204,252,0,0,204,0,0,0,174,0,0,204,0,0,16,174,0,0,204,
0,0,0,174,0,0,204,0,0,0,174,0,0,204,1,0,16,174,0,0,204,0,0,0,174,0,0,191,170,170,170,236,
0,0,60,238,238,238,195,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,21,0,0,0,81,95,160,0,
9,245,26,250,0,159,177,0,175,168,251,16,0,10,255,177,0,0,8,255,160,0,0,159,186,250,0,25,251,16,175,161,
95,177,0,10,245,21,16,0,0,81,0,0,0,0,85,0,0,0,3,255,48,0,0,2,221,32,0,0,0,0,0,0,
125,204,204,204,216,125,238,238,238,231,0,0,0,0,0,0,2,221,32,0,0,3,255,48,0,0,0,85,0,0,0,0,
0,0,35,51,51,51,51,16,0,0,207,255,255,255,255,144,0,8,246,68,69,68,76,192,0,95,112,10,32,120,10,192,
2,250,1,30,212,249,11,192,29,193,0,1,207,160,11,192,30,176,0,0,207,128,11,192,3,249,1,29,230,249,11,192,
0,127,80,26,48,120,11,192,0,10,244,50,35,34,59,192,0,0,207,255,255,255,255,160,0,0,21,85,85,85,85,16,
0,0,2,32,0,0,0,0,13,225,0,0,0,0,174,236,0,0,0,9,244,47,176,0,0,143,80,4,249,0,6,249,
0,0,127,128,46,255,160,9,255,242,3,76,192,11,212,48,0,10,192,10,192,0,1,11,211,59,208,0,0,9,255,255,
160,0,0,1,85,85,16,0
};
static const uint32_t ASSET_BYTES = 32744;


static const uint8_t IC_SW_D24[288] = {
0, 0, 0, 0, 20, 68, 68, 65, 0, 0, 0, 0, 0, 0, 0, 0, 111, 255, 255, 246, 0, 0, 0, 0,
0, 0, 0, 0, 18, 255, 255, 33, 0, 0, 0, 0, 0, 0, 0, 0, 0, 255, 255, 0, 0, 0, 0, 0,
0, 0, 0, 0, 1, 255, 255, 16, 0, 0, 0, 0, 0, 0, 0, 5, 207, 255, 255, 252, 80, 37, 0, 0,
0, 0, 1, 191, 253, 168, 138, 223, 251, 239, 80, 0, 0, 0, 29, 253, 80, 0, 0, 5, 223, 255, 80, 0,
0, 0, 191, 177, 0, 0, 0, 89, 43, 252, 0, 0, 0, 6, 253, 16, 0, 0, 2, 239, 129, 223, 96, 0,
0, 13, 244, 0, 0, 0, 11, 253, 16, 79, 208, 0, 0, 63, 192, 0, 0, 0, 127, 243, 0, 12, 243, 0,
0, 127, 128, 0, 0, 6, 255, 112, 0, 8, 247, 0, 0, 159, 96, 0, 0, 143, 252, 0, 0, 6, 249, 0,
0, 159, 96, 0, 0, 159, 249, 0, 0, 6, 249, 0, 0, 127, 112, 0, 0, 43, 178, 0, 0, 7, 247, 0,
0, 95, 160, 0, 0, 0, 0, 0, 0, 10, 245, 0, 0, 30, 242, 0, 0, 0, 0, 0, 0, 47, 225, 0,
0, 8, 250, 0, 0, 0, 0, 0, 0, 175, 128, 0, 0, 1, 223, 112, 0, 0, 0, 0, 7, 253, 16, 0,
0, 0, 78, 250, 16, 0, 0, 1, 175, 228, 0, 0, 0, 0, 4, 239, 233, 83, 53, 158, 254, 64, 0, 0,
0, 0, 0, 41, 255, 255, 255, 255, 146, 0, 0, 0, 0, 0, 0, 0, 38, 155, 185, 98, 0, 0, 0, 0,
};
static const uint8_t IC_SW_D40[800] = {
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 123, 187, 187, 187, 187, 183, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 159,
255, 255, 255, 255, 249, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 105, 191, 255, 255, 251,
150, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 111, 255, 255, 246, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 111, 255, 255, 246, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, 0, 0, 0, 0, 111, 255, 255, 246, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, 111, 255, 255, 246, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 107,
255, 255, 255, 255, 182, 16, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 1, 142, 255, 255, 255, 255, 255,
255, 232, 16, 10, 112, 0, 0, 0, 0, 0, 0, 0, 0, 77, 255, 255, 255, 220, 205, 255, 255, 255, 212, 175,
247, 0, 0, 0, 0, 0, 0, 0, 7, 255, 255, 249, 65, 0, 0, 20, 159, 255, 255, 255, 255, 96, 0, 0,
0, 0, 0, 0, 143, 255, 249, 16, 0, 0, 0, 0, 1, 159, 255, 255, 253, 16, 0, 0, 0, 0, 0, 6,
255, 254, 64, 0, 0, 0, 0, 0, 36, 4, 239, 255, 209, 0, 0, 0, 0, 0, 0, 63, 255, 210, 0, 0,
0, 0, 0, 0, 207, 128, 45, 255, 243, 0, 0, 0, 0, 0, 0, 207, 254, 32, 0, 0, 0, 0, 0, 8,
255, 250, 2, 239, 252, 0, 0, 0, 0, 0, 5, 255, 245, 0, 0, 0, 0, 0, 0, 79, 255, 243, 0, 95,
255, 80, 0, 0, 0, 0, 12, 255, 176, 0, 0, 0, 0, 0, 1, 223, 255, 112, 0, 11, 255, 192, 0, 0,
0, 0, 47, 255, 64, 0, 0, 0, 0, 0, 9, 255, 251, 0, 0, 4, 255, 242, 0, 0, 0, 0, 127, 253,
0, 0, 0, 0, 0, 0, 95, 255, 226, 0, 0, 0, 223, 247, 0, 0, 0, 0, 175, 249, 0, 0, 0, 0,
0, 3, 239, 255, 80, 0, 0, 0, 159, 250, 0, 0, 0, 0, 223, 246, 0, 0, 0, 0, 1, 191, 255, 250,
0, 0, 0, 0, 111, 253, 0, 0, 0, 0, 255, 244, 0, 0, 0, 0, 8, 255, 255, 225, 0, 0, 0, 0,
79, 255, 0, 0, 0, 0, 255, 244, 0, 0, 0, 0, 11, 255, 255, 176, 0, 0, 0, 0, 79, 255, 0, 0,
0, 0, 255, 244, 0, 0, 0, 0, 10, 255, 255, 160, 0, 0, 0, 0, 79, 255, 0, 0, 0, 0, 223, 245,
0, 0, 0, 0, 2, 223, 253, 32, 0, 0, 0, 0, 95, 253, 0, 0, 0, 0, 191, 248, 0, 0, 0, 0,
0, 21, 81, 0, 0, 0, 0, 0, 143, 251, 0, 0, 0, 0, 143, 252, 0, 0, 0, 0, 0, 0, 0, 0,
0, 0, 0, 0, 207, 248, 0, 0, 0, 0, 79, 255, 48, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 3,
255, 244, 0, 0, 0, 0, 13, 255, 144, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 9, 255, 208, 0, 0,
0, 0, 7, 255, 243, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 63, 255, 112, 0, 0, 0, 0, 0, 223,
253, 16, 0, 0, 0, 0, 0, 0, 0, 0, 1, 223, 253, 0, 0, 0, 0, 0, 0, 79, 255, 177, 0, 0,
0, 0, 0, 0, 0, 0, 27, 255, 244, 0, 0, 0, 0, 0, 0, 8, 255, 252, 32, 0, 0, 0, 0, 0,
0, 2, 207, 255, 128, 0, 0, 0, 0, 0, 0, 0, 175, 255, 230, 0, 0, 0, 0, 0, 0, 110, 255, 250,
0, 0, 0, 0, 0, 0, 0, 0, 10, 255, 255, 198, 16, 0, 0, 1, 108, 255, 255, 160, 0, 0, 0, 0,
0, 0, 0, 0, 0, 127, 255, 255, 253, 169, 154, 223, 255, 255, 247, 0, 0, 0, 0, 0, 0, 0, 0, 0,
0, 3, 191, 255, 255, 255, 255, 255, 255, 251, 48, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 3, 158,
255, 255, 255, 255, 233, 48, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 54, 137, 152, 99,
0, 0, 0, 0, 0, 0, 0, 0,
};

static const uint8_t* ASSET = ASSET_BIN;
static AFont F7, F8, F9, F10, B9, B13, B29, N30, CLK;
static AIcon IC_FOLDER, IC_CALC, IC_NOTES, IC_TOOLS, IC_THEME, IC_GEAR;
static AIcon IC_FOLDER_BIG, IC_CALC_BIG, IC_NOTES_BIG, IC_TOOLS_BIG, IC_THEME_BIG, IC_GEAR_BIG;
static AIcon IC_WIFI, IC_CHECK, IC_CHEV_R, IC_CHEV_L, IC_CLOSE;
static AIcon IC_NAV_BACK, IC_NAV_HOME, IC_NAV_RECENT, IC_MUL, IC_DIV, IC_BKSP, IC_SHIFT;

static bool initAssets() {
  F7 = {32,90,(const AGlyph*)(ASSET+0),ASSET+472};
  F8 = {32,126,(const AGlyph*)(ASSET+808),ASSET+1568};
  F9 = {32,126,(const AGlyph*)(ASSET+2896),ASSET+3656};
  F10 = {32,126,(const AGlyph*)(ASSET+5452),ASSET+6212};
  B9 = {32,126,(const AGlyph*)(ASSET+8144),ASSET+8904};
  B13 = {32,126,(const AGlyph*)(ASSET+10800),ASSET+11560};
  B29 = {79,115,(const AGlyph*)(ASSET+15220),ASSET+15516};
  N30 = {43,114,(const AGlyph*)(ASSET+16528),ASSET+17104};
  CLK = {48,58,(const AGlyph*)(ASSET+19740),ASSET+19828};
  IC_FOLDER = {24,24,ASSET+25412};
  IC_FOLDER_BIG = {40,40,ASSET+25700};
  IC_CALC = {24,24,ASSET+26500};
  IC_CALC_BIG = {40,40,ASSET+26788};
  IC_NOTES = {24,24,ASSET+27588};
  IC_NOTES_BIG = {40,40,ASSET+27876};
  IC_TOOLS = {24,24,IC_SW_D24};   // ikon stopwatch (menggantikan ikon Alat)
  IC_TOOLS_BIG = {40,40,IC_SW_D40};
  IC_THEME = {24,24,ASSET+29764};
  IC_THEME_BIG = {40,40,ASSET+30052};
  IC_GEAR = {24,24,ASSET+30852};
  IC_GEAR_BIG = {40,40,ASSET+31140};
  IC_WIFI = {15,11,ASSET+31940};
  IC_CHECK = {8,8,ASSET+32024};
  IC_CHEV_R = {6,10,ASSET+32056};
  IC_CHEV_L = {6,10,ASSET+32088};
  IC_CLOSE = {10,10,ASSET+32120};
  IC_NAV_BACK = {14,14,ASSET+32172};
  IC_NAV_HOME = {14,14,ASSET+32272};
  IC_NAV_RECENT = {14,14,ASSET+32372};
  IC_MUL = {10,10,ASSET+32472};
  IC_DIV = {10,10,ASSET+32524};
  IC_BKSP = {16,12,ASSET+32576};
  IC_SHIFT = {12,12,ASSET+32672};
  return sizeof(ASSET_BIN) == ASSET_BYTES;
}

// ============================== FRAMEBUFFER ==================================
static const size_t FB_BYTES = (size_t)SCR_W * SCR_H * 2;
static u16* fb      = nullptr;
static u16* bgBuf   = nullptr;
static u16* snapBuf = nullptr;        // cuplikan layar LAMA (transisi, crossfade boot)
static u16* snapBuf2 = nullptr;       // cuplikan layar BARU (transisi)
static u16* fbAlt   = nullptr;        // buffer kedua untuk pipeline render <-> kirim ke TFT
static int  bgTheme = -1;

static u16* allocFrame(bool mustHave) {
  // Selalu coba PSRAM dulu — N16R8 punya 8 MB, lebih dari cukup untuk 3 FB × 150 KB
  u16* p = (u16*)PSRAM_MALLOC(FB_BYTES);
  if (p) { memset(p, 0, FB_BYTES); return p; }

  // Fallback ke internal RAM hanya jika PSRAM gagal (misal PSRAM belum diaktifkan di Arduino IDE)
  if (mustHave) {
    p = (u16*)heap_caps_malloc(FB_BYTES, MALLOC_CAP_INTERNAL | MALLOC_CAP_8BIT);
    if (!p) p = (u16*)heap_caps_malloc(FB_BYTES, MALLOC_CAP_8BIT);
    if (p) memset(p, 0, FB_BYTES);
  }
  return p;
}

SPIClass tftSPI(FSPI);
Adafruit_ILI9341 tft(&tftSPI, PIN_TFT_DC, PIN_TFT_CS, PIN_TFT_RST);
Preferences prefs;

static uint8_t blLevel = 255;           // kecerahan aktif (0..255)
static int brightPct = 100;             // 10..100

// ---- pengiriman frame ke TFT: sinkron (pushFrame) atau latar belakang (presentFrame) ----
// presentFrame() mengirim fb lewat task di core 0 sambil core 1 menggambar frame berikutnya
// (render & transfer SPI jadi tumpang-tindih -> animasi jauh lebih mulus).
static TaskHandle_t  pushTaskH = nullptr;
static volatile bool pushBusy  = false;
static const u16*    pushSrc   = nullptr;

static void tftBlast(const u16* src) {
  tft.startWrite();
  tft.setAddrWindow(0, 0, SCR_W, SCR_H);
  tft.writePixels((uint16_t*)src, (uint32_t)SCR_W * SCR_H, true, false);
  tft.endWrite();
}
static void pushWorker(void*) {
  for (;;) {
    ulTaskNotifyTake(pdTRUE, portMAX_DELAY);
    tftBlast(pushSrc);
    pushBusy = false;
  }
}
static inline void waitPush() {
  uint32_t t = millis();
  while (pushBusy) { if (millis() - t > 250) { pushBusy = false; break; } delayMicroseconds(120); }
}
static void pushFrame() { waitPush(); tftBlast(fb); }
static void startPushTask() {
  if (fbAlt && !pushTaskH) xTaskCreatePinnedToCore(pushWorker, "tftpush", 4096, nullptr, 2, &pushTaskH, 0);
}
static void presentFrame() {
  if (!pushTaskH || !fbAlt) { pushFrame(); return; }
  waitPush();
  pushSrc = fb; pushBusy = true;
  xTaskNotifyGive(pushTaskH);
  u16* t = fb; fb = fbAlt; fbAlt = t;            // gambar frame berikutnya di buffer yang satunya
}
static void setBacklight(uint8_t v) {
#if defined(ESP_ARDUINO_VERSION_MAJOR) && ESP_ARDUINO_VERSION_MAJOR >= 3
  ledcWrite(PIN_TFT_BL, v);
#else
  ledcWrite(0, v);
#endif
}
static void fadeBacklight(int from, int to, int ms) {
  uint32_t t0 = millis();
  for (;;) {
    uint32_t dt = millis() - t0; if (dt >= (uint32_t)ms) break;
    setBacklight(from + (to - from) * (int)dt / ms); delay(8);
  }
  setBacklight(to);
}
static void applyBrightness() { blLevel = 25 + (230 * brightPct) / 100; setBacklight(blLevel); }

// ============================== PRIMITIF GAMBAR ==============================
static inline void px(int x, int y, u16 c, uint8_t a) {
  if ((unsigned)x >= SCR_W || (unsigned)y >= SCR_H || a == 0) return;
  u16* p = fb + y * SCR_W + x;
  *p = (a == 255) ? c : mix(c, *p, a);
}
static void fillSolid(u16 c) { for (int i = 0; i < SCR_W * SCR_H; i++) fb[i] = c; }

// cakupan (0..1) satu piksel terhadap kotak membulat (fill atau outline)
static inline float rrCov(float pxc, float pyc, float cx, float cy, float ax, float ay, float r, float stroke) {
  float dx = fabsf(pxc - cx) - ax, dy = fabsf(pyc - cy) - ay;
  float ox = dx > 0 ? dx : 0, oy = dy > 0 ? dy : 0;
  float outside = (ox > 0 && oy > 0) ? sqrtf(ox * ox + oy * oy) : (ox > oy ? ox : oy);
  float inside = dx > dy ? dx : dy; if (inside > 0) inside = 0;
  float sd = outside + inside - r;
  float cov = (stroke <= 0) ? (0.5f - sd) : (0.5f - fabsf(sd + stroke * 0.5f) + stroke * 0.5f);
  return cov <= 0 ? 0 : (cov > 1 ? 1 : cov);
}

// Kotak membulat anti-alias. Bagian tengah tiap baris (jauh dari tepi/sudut) hasilnya sama untuk
// semua kolom, jadi dihitung SEKALI lalu diisi sebagai span -> 4-6x lebih cepat dari versi per-piksel.
static void rrect(float x, float y, float w, float h, float r, u16 c, uint8_t alpha = 255, float stroke = 0) {
  if (alpha == 0 || w <= 0 || h <= 0) return;
  float hw = w * 0.5f, hh = h * 0.5f, cx = x + hw, cy = y + hh;
  if (r > hw) r = hw; if (r > hh) r = hh; if (r < 0) r = 0;
  float ax = hw - r, ay = hh - r;
  int x0 = (int)floorf(x) - 1, x1 = (int)ceilf(x + w) + 1, y0 = (int)floorf(y) - 1, y1 = (int)ceilf(y + h) + 1;
  if (x0 < 0) x0 = 0; if (y0 < 0) y0 = 0; if (x1 > SCR_W) x1 = SCR_W; if (y1 > SCR_H) y1 = SCR_H;
  if (x0 >= x1 || y0 >= y1) return;
  float m = ax - (stroke > 0 ? stroke : 0) - 1.5f;         // setengah lebar area tengah yang seragam
  int ls = x1, rs = x1;
  if (m > 1.0f) {
    int a = (int)ceilf(cx - m - 0.5f), b = (int)floorf(cx + m - 0.5f) + 1;
    if (a < x0) a = x0; if (b > x1) b = x1;
    if (b > a) { ls = a; rs = b; }
  }
  for (int j = y0; j < y1; j++) {
    float pyc = j + 0.5f;
    int i = x0;
    for (; i < ls; i++) {
      float cv = rrCov(i + 0.5f, pyc, cx, cy, ax, ay, r, stroke);
      if (cv > 0) px(i, j, c, (uint8_t)(cv * alpha));
    }
    if (rs > ls) {
      uint8_t a8 = (uint8_t)(rrCov(cx, pyc, cx, cy, ax, ay, r, stroke) * alpha);
      if (a8) {
        u16* p = fb + j * SCR_W;
        if (a8 == 255) { for (int k = ls; k < rs; k++) p[k] = c; }
        else           { for (int k = ls; k < rs; k++) p[k] = mix(c, p[k], a8); }
      }
      i = rs;
    }
    for (; i < x1; i++) {
      float cv = rrCov(i + 0.5f, pyc, cx, cy, ax, ay, r, stroke);
      if (cv > 0) px(i, j, c, (uint8_t)(cv * alpha));
    }
  }
}
static inline void disc(float cx, float cy, float r, u16 c, uint8_t a = 255) { rrect(cx - r, cy - r, 2 * r, 2 * r, r, c, a); }
static inline void ringS(float cx, float cy, float r, float t, u16 c, uint8_t a = 255) { rrect(cx - r, cy - r, 2 * r, 2 * r, r, c, a, t); }

static void arcLine(float cx, float cy, float r, float th, float a0, float a1, u16 c, uint8_t alpha) {
  int x0 = (int)(cx - r - th - 2), x1 = (int)(cx + r + th + 2), y0 = (int)(cy - r - th - 2), y1 = (int)(cy + r + th + 2);
  if (x0 < 0) x0 = 0; if (y0 < 0) y0 = 0; if (x1 > SCR_W) x1 = SCR_W; if (y1 > SCR_H) y1 = SCR_H;
  for (int j = y0; j < y1; j++) for (int i = x0; i < x1; i++) {
    float dx = i + 0.5f - cx, dy = j + 0.5f - cy;
    float d = sqrtf(dx * dx + dy * dy), e = fabsf(d - r);
    if (e > th * 0.5f + 1) continue;
    float ang = atan2f(dy, dx) * 57.29578f; if (ang < 0) ang += 360;
    float rel = ang - a0; while (rel < 0) rel += 360;
    if (rel > a1 - a0) continue;
    float cov = th * 0.5f + 0.5f - e; if (cov <= 0) continue; if (cov > 1) cov = 1;
    px(i, j, c, (uint8_t)(cov * alpha));
  }
}
static void glow(int cx, int cy, int r, u16 c, uint8_t maxA) {
  int x0 = cx - r, x1 = cx + r, y0 = cy - r, y1 = cy + r, r2 = r * r;
  if (x0 < 0) x0 = 0; if (y0 < 0) y0 = 0; if (x1 > SCR_W) x1 = SCR_W; if (y1 > SCR_H) y1 = SCR_H;
  for (int j = y0; j < y1; j++) for (int i = x0; i < x1; i++) {
    int dx = i - cx, dy = j - cy, d2 = dx * dx + dy * dy;
    if (d2 >= r2) continue;
    float t = 1.0f - sqrtf((float)d2) / r;
    px(i, j, c, (uint8_t)(maxA * t * t));
  }
}

// ---- gelapkan area dengan hitam (alpha a) secara cepat: k = 32 * (255 - a) / 255 ----
static inline void dimSpan(u16* p, int n, uint32_t k) {
  for (int i = 0; i < n; i++) {
    uint32_t v = p[i];
    v = (v | (v << 16)) & 0x07E0F81FUL;
    v = ((v * k) >> 5) & 0x07E0F81FUL;
    p[i] = (u16)(v | (v >> 16));
  }
}
static void dimRows(int y0, int y1, uint8_t a) {
  if (y0 < 0) y0 = 0; if (y1 > SCR_H) y1 = SCR_H;
  if (a == 0 || y0 >= y1) return;
  uint32_t k = (uint32_t)(255 - a) * 32 / 255;
  for (int y = y0; y < y1; y++) dimSpan(fb + y * SCR_W, SCR_W, k);
}

// ---- tempel cuplikan layar penuh (240x320) yang diskala ke kotak [X0,X1) x [Y0,Y1) dengan sudut membulat ----
static void blitScaled(const u16* src, int X0, int Y0, int X1, int Y1, int rad, uint8_t alpha) {
  int W = X1 - X0, Hh = Y1 - Y0;
  if (W < 2 || Hh < 2 || alpha == 0) return;
  static int16_t xmap[SCR_W];
  int cx0 = X0 < 0 ? 0 : X0, cx1 = X1 > SCR_W ? SCR_W : X1;
  int cy0 = Y0 < 0 ? 0 : Y0, cy1 = Y1 > SCR_H ? SCR_H : Y1;
  if (cx0 >= cx1 || cy0 >= cy1) return;
  for (int x = cx0; x < cx1; x++) xmap[x] = (int16_t)(((int32_t)(x - X0) * SCR_W) / W);
  if (rad > W / 2) rad = W / 2;
  if (rad > Hh / 2) rad = Hh / 2;
  for (int y = cy0; y < cy1; y++) {
    int sy = (int)(((int32_t)(y - Y0) * SCR_H) / Hh);
    const u16* srow = src + sy * SCR_W;
    u16* drow = fb + y * SCR_W;
    int xa = cx0, xb = cx1;
    if (rad > 0) {
      int dy = (y - Y0 < rad) ? rad - (y - Y0) : ((Y1 - 1 - y < rad) ? rad - (Y1 - 1 - y) : 0);
      if (dy > 0) {
        int inset = rad - (int)sqrtf((float)(rad * rad - dy * dy));
        if (xa < X0 + inset) xa = X0 + inset;
        if (xb > X1 - inset) xb = X1 - inset;
      }
    }
    if (alpha == 255) { for (int x = xa; x < xb; x++) drow[x] = srow[xmap[x]]; }
    else              { for (int x = xa; x < xb; x++) drow[x] = mix(srow[xmap[x]], drow[x], alpha); }
  }
}

// ---- teks (font 4-bit anti-alias). align: 0 kiri, 1 tengah, 2 kanan
static int charAdv16(const AFont& f, uint8_t ch) { if (ch < f.first || ch > f.last) return 0; return f.g[ch - f.first].adv; }
static int textWidth(const AFont& f, const char* s) {
  int pen = 0;
  for (; *s; s++) pen += charAdv16(f, (uint8_t)*s);
  return (pen + 8) >> 4;
}
static void blit4(const uint8_t* d, int w, int h, int x, int y, u16 c, uint8_t alpha) {
  if (x >= SCR_W || y >= SCR_H || x + w <= 0 || y + h <= 0) return;
  int idx = 0;
  for (int j = 0; j < h; j++) {
    for (int i = 0; i < w; i++, idx++) {
      uint8_t b = d[idx >> 1];
      uint8_t n = (idx & 1) ? (b & 0x0F) : (b >> 4);
      if (!n) continue;
      px(x + i, y + j, c, (uint8_t)((n * 17 * alpha) / 255));
    }
  }
}
static int drawText(const AFont& f, int x, int base, const char* s, u16 c, uint8_t alpha = 255, int align = 0) {
  int tw = textWidth(f, s);
  if (align == 1) x -= tw / 2; else if (align == 2) x -= tw;
  int pen = 0;
  for (const char* p = s; *p; p++) {
    uint8_t ch = (uint8_t)*p; if (ch < f.first || ch > f.last) continue;
    const AGlyph& g = f.g[ch - f.first];
    if (g.w) blit4(f.bmp + g.off, g.w, g.h, x + ((pen + 8) >> 4) + g.xo, base + g.yo, c, alpha);
    pen += g.adv;
  }
  return tw;
}
static void drawIcon(const AIcon& ic, float cx, float cy, u16 c, uint8_t alpha = 255) {
  blit4(ic.d, ic.w, ic.h, (int)floorf(cx - ic.w * 0.5f + 0.5f), (int)floorf(cy - ic.h * 0.5f + 0.5f), c, alpha);
}

static void fitText(const AFont& f, const char* str, int maxw, char* out, int outsz) {
  strncpy(out, str, outsz - 1); out[outsz - 1] = 0;
  if (textWidth(f, out) <= maxw) return;
  int n = (int)strlen(out);
  while (n > 0 && textWidth(f, out) + textWidth(f, "..") > maxw) out[--n] = 0;
  snprintf(out + n, outsz - n, "..");
}
// pecah teks menjadi baris (word wrap). Mengembalikan jumlah baris.
static int wrapLines(const AFont& f, int width, const char* text, const char** st, int* ln, int maxL) {
  int n = 0; const char* p = text;
  while (*p && n < maxL) {
    int w = 0; const char* q = p; const char* lastSp = nullptr;
    while (*q && *q != '\n') {
      int a = charAdv16(f, (uint8_t)*q);
      if (((w + a + 8) >> 4) > width) break;
      if (*q == ' ') lastSp = q;
      w += a; q++;
    }
    const char* end = q;
    if (*q && *q != '\n' && lastSp && lastSp > p) end = lastSp;
    if (end == p && *q && *q != '\n') end = p + 1;
    st[n] = p; ln[n] = (int)(end - p); n++;
    p = end; if (*p == '\n' || *p == ' ') p++;
  }
  return n;
}
static void drawLines(const AFont& f, int x, int base, int lineH, const char** st, int* ln, int from, int to, u16 c) {
  char buf[80];
  for (int i = from; i < to; i++) {
    int n = ln[i]; if (n > 79) n = 79;
    memcpy(buf, st[i], n); buf[n] = 0;
    drawText(f, x, base + (i - from) * lineH, buf, c);
  }
}

// ============================== WAKTU ========================================
static const char* HARI[7]   = {"Minggu","Senin","Selasa","Rabu","Kamis","Jumat","Sabtu"};
static const char* BULAN[12] = {"Januari","Februari","Maret","April","Mei","Juni","Juli","Agustus","September","Oktober","November","Desember"};
static const uint8_t HARI_BULAN[12] = {31,28,31,30,31,30,31,31,30,31,30,31};
static uint32_t lastMinuteMs = 0;

static int daysInMonth(int mo) {
  if (mo == 1) { bool leap = (clk_yy % 4 == 0 && clk_yy % 100 != 0) || (clk_yy % 400 == 0); return leap ? 29 : 28; }
  return HARI_BULAN[mo];
}
static bool tickClock(uint32_t now) {
  bool ch = false;
  while (now - lastMinuteMs >= 60000UL) {
    lastMinuteMs += 60000UL; ch = true;
    if (++clk_mm >= 60) { clk_mm = 0;
      if (++clk_hh >= 24) { clk_hh = 0; clk_wd = (clk_wd + 1) % 7;
        if (++clk_dd > daysInMonth(clk_mo)) { clk_dd = 1; if (++clk_mo >= 12) { clk_mo = 0; clk_yy++; } } } }
  }
  return ch;
}

// ============================== STATE ========================================
#define APP_COUNT  9                              // 6 aplikasi (halaman 1) + 3 game (halaman 2)
#define HOME_PAGES 2
static App APPS[APP_COUNT];
// beranda geser: homePos = posisi gulir (px), homePage = halaman tujuan
static int   homePage = 0;
static float homePos = 0, homeV = 0, homeDragP0 = 0;
static bool  homeDrag = false, homeSpring = false;
static inline bool homeSettled() { return !homeDrag && !homeSpring; }
static float homeRubber(float p) { float mx = (float)((HOME_PAGES - 1) * 240); if (p < 0) return p * 0.35f; if (p > mx) return mx + (p - mx) * 0.35f; return p; }
static Screen screen = SC_HOME;
static int  curTheme = 0;
static bool sheetOpen = false;
static float sheetAnim = 0;
static uint32_t lastAnimMs = 0;
static bool dirty = true, sleeping = false;
static int  pressedId = -1, pressedNav = -1;

static const int COLX[3] = {48, 120, 192};
static const int ROWY[2] = {166, 234};
static const int NAV_Y = 288;                    // area tombol navigasi: y >= 288
static const int NAVX[3] = {60, 120, 180};
static const int SHEET_TOP_OPEN = 185;

static Btn btns[56];
static int nbtn = 0;
static int8_t recents[4] = {-1, -1, -1, -1};
static bool fsOK = false;

// ---- Control panel, lock screen, Wi-Fi, senter ----
#define CP_H 258                                   // tinggi control panel (px)
static bool  locked = true;                        // lock screen aktif
static int   lockShift = 0;                        // geser ke atas saat membuka kunci (px)
static bool  lockDrag = false;
static bool  cpOpen = false, cpDrag = false, cpSlide = false, cpLongDone = false;
static float cpAnim = 0;
static uint8_t cpMode = 0;                         // 0 normal, 1 pilih warna senter, 2 konfirmasi deep sleep
static int8_t  cpPress = -1;                       // tile yang sedang ditekan

// ---- animasi pegas, efek sentuh, transisi (v1.4) ----
static float sheetV = 0, cpV = 0;                   // kecepatan pegas sheet tema & control panel
static float cpDragP0 = 0; static int cpDragY0 = 0; // titik awal tarikan control panel
static float cpHold = 0;                            // progres tahan (0..1) tile Wi-Fi / Senter
static float bpX[56], bpV[56];                      // pegas tekan tiap tombol (0 = lepas, 1 = ditekan)
static float navSp[3], navSv[3];                    // pegas tombol navigasi
static float cpSx[6], cpSv[6];                      // pegas tekan tile control panel
static float topHintX = 0, topHintV = 0;            // petunjuk "tarik" di tepi atas saat disentuh
static Ripple rip = {false, -1, 0, 0, 0};           // riak sentuhan
static bool  lockSpring = false, lockSnapOK = false;// animasi buka/batal kunci
static float lockPos = 0, lockVel = 0, lockTarget = 0;

// ---- status sentuhan ----
static bool tDown = false, ignoreTouch = false, swipeTop = false, tBlocked = false;
static int t0x, t0y, tx, ty, tMiss = 0, tPend = 0;
static uint32_t tT0 = 0, bsNext = 0, tMissT0 = 0, tLastMs = 0;

#include "games.h"      // Dino, Ping Pong, Flappy Bird (butuh variabel sentuh di atas)
static float fxs = 0, fys = 0, tvy = 0, tLastY = 0, tvx = 0, tLastX = 0;  // koordinat tersaring & kecepatan vertikal (px/detik)

// ---- kunci layar: PIN (4-8 angka) atau pola 3x3 ----
static uint8_t  lkType = 0;                         // 0 tanpa kunci, 1 PIN, 2 pola
static uint32_t lkHash = 0;                         // hash PIN/pola (tidak menyimpan teks asli)
static bool     lockAuth = false;                   // lock screen sedang meminta PIN/pola
static uint32_t lockAuthT = 0, lockAuthLast = 0;
static uint8_t  credPurpose = 0;                    // 0 buka kunci, 1 verifikasi sebelum ubah, 2 buat baru, 3 konfirmasi
static char     credBuf[10], credTmp[10], credMsg[44];
static uint8_t  credLen = 0, credFails = 0;
static bool     credMsgErr = false, credTouch = false, credCancelDown = false;
static uint32_t credShakeT = 0, credPopT = 0, credLockUntil = 0, credMsgT = 0;
static int8_t   credKey = -1;
static float    credSp[12], credSv[12];
static uint8_t  patSeq[9]; static uint8_t patLen = 0;
static bool     patDrag = false, patErr = false;
static uint32_t patErrT = 0;
static float    patFx = 0, patFy = 0;
static int  credKind() { return locked ? lkType : (screen == SC_PINPAD ? 1 : 2); }
static bool credScreen() { return !locked && (screen == SC_PINPAD || screen == SC_PATTERN); }
static void credReset() {
  credLen = 0; credBuf[0] = 0; patLen = 0; patDrag = false; patErr = false;
  credMsg[0] = 0; credKey = -1; credTouch = false; credCancelDown = false;
}

static const uint8_t WF_OFF = 0, WF_CONNECTING = 1, WF_ON = 2, WF_FAIL = 3;
static uint8_t  wifiSt = WF_OFF;
static bool     wifiWant = true, ntpPending = false, timeSynced = false;
static uint32_t wifiT0 = 0, ntpLastMs = 0;

// ---- Pengaturan Wi-Fi: daftar jaringan, password, keyboard ----
#define WIFI_SCAN_MS   2000UL                      // jeda antar pemindaian di layar Wi-Fi (2 detik sekali)
static char wifiSsid[33] = "";                     // jaringan tersimpan (dimuat dari flash saat boot)
static char wifiPass[64] = "";
static char pendSsid[33] = "", pendPass[64] = ""; // jaringan yang sedang dicoba disambung
static bool pendSave = false;                      // true = simpan kredensial bila berhasil tersambung
static WfNet wfNet[16];
static int   wfCount = 0, wfPage = 0;
static bool  wfScanRunning = false;
static uint32_t wfScanT0 = 0;
static char  wfToast[40] = "";
static uint32_t wfToastUntil = 0;
static char  selSsid[33] = "";                     // jaringan yang dipilih dari daftar
static bool  selSecure = true;
static char  pwBuf[64] = "";                       // password yang sedang diketik
static int   pwLen = 0;
static bool  pwShow = false, pwMsgErr = false;
static uint32_t pwLastMs = 0, pwMsgUntil = 0, shiftTapMs = 0;
static char  pwMsg[44] = "";
static int   kbL = 0;                              // keyboard HP: 0 abc, 1 Abc, 2 ABC (caps lock), 3 simbol 1, 4 simbol 2
static inline bool pwBusy() { return pendSave && wifiSt == WF_CONNECTING; }

static bool    flashOn = false;
static uint8_t flashIdx = 0;                       // 0 = putih
static const uint8_t FL_RGB[8][3] = {
  {255,255,255}, {255,40,30}, {255,140,0}, {255,214,10}, {0,230,80}, {0,210,255}, {20,80,255}, {190,60,255}
};
static const char* FL_NAME[8] = {"Putih","Merah","Oranye","Kuning","Hijau","Cyan","Biru","Ungu"};

// ============================== WALLPAPER ====================================
static void renderBG(const Theme& t) {
  for (int y = 0; y < SCR_H; y++) {
    u16 c = mix(t.bgBot, t.bgTop, (uint8_t)(255 - y * 255 / (SCR_H - 1)));
    u16* row = fb + y * SCR_W;
    for (int x = 0; x < SCR_W; x++) row[x] = c;
  }
  glow(218, 238, 118, t.glowA, t.gaA);
  glow(6, 322, 105, t.glowB, t.gaB);
  arcLine(318, 262, 128, 1.6f, 128, 232, t.arc, t.arcAlpha);
  arcLine(318, 262, 146, 1.4f, 132, 228, t.arc, t.arcAlpha * 2 / 3);
  arcLine(318, 262, 166, 1.2f, 136, 224, t.arc, t.arcAlpha / 2);
}
static void copyBG() {
  if (bgBuf) {
    if (bgTheme != curTheme) { renderBG(THEMES[curTheme]); memcpy(bgBuf, fb, FB_BYTES); bgTheme = curTheme; }
    else memcpy(fb, bgBuf, FB_BYTES);
  } else renderBG(THEMES[curTheme]);
}

// ============================== EASING =======================================
static float easeOut(float x) { x = x < 0 ? 0 : (x > 1 ? 1 : x); return 1 - (1 - x) * (1 - x) * (1 - x); }
static float smooth(float x)  { x = x < 0 ? 0 : (x > 1 ? 1 : x); return x * x * (3 - 2 * x); }
static float clamp01(float v) { return v < 0 ? 0 : (v > 1 ? 1 : v); }
static float easeUI(float x)  { float a = easeOut(x), b = smooth(x); return a * 0.7f + b * 0.3f; }   // start lembut, akhir melambat

// pegas (semi-implicit Euler, dipecah jadi langkah kecil agar stabil walau frame lambat)
static void springStep(float& x, float& v, float target, float dt, float k, float c) {
  while (dt > 0) {
    float h = dt > 0.008f ? 0.008f : dt;
    v += (k * (target - x) - c * v) * h;
    x += v * h;
    dt -= h;
  }
}

// ============================== TRANSISI LAYAR ===============================
// Layar lama & baru dirender ke snapBuf / snapBuf2, lalu tiap frame hanya digabung (murah):
//   ZOOM_OPEN  : jendela aplikasi membesar dari ikon di beranda
//   ZOOM_CLOSE : jendela aplikasi mengecil kembali ke ikonnya
//   SLIDE_FWD / SLIDE_BACK : masuk / keluar sub-layar dengan paralaks + bayangan tepi
//   FADE       : pudar silang (layar lain)
static const uint8_t TR_NONE = 0, TR_ZOOM_OPEN = 1, TR_ZOOM_CLOSE = 2, TR_SLIDE_FWD = 3, TR_SLIDE_BACK = 4, TR_FADE = 5;
static bool     trActive = false;
static uint8_t  trKind = TR_NONE;
static uint32_t trT0 = 0;
static uint16_t trDur = 0;
static float    trIcx = 120, trIcy = 160;

static inline bool trReady() { return UI_SMOOTH && snapBuf && snapBuf2; }
static void trBegin(uint8_t kind, uint16_t dur) { trKind = kind; trDur = dur; trT0 = millis(); trActive = true; }

static void trZoom(const u16* base, const u16* win, float p) {
  memcpy(fb, base, FB_BYTES);
  dimRows(0, SCR_H, (uint8_t)(110.0f * p));
  float L = trIcx - 20, T = trIcy - 20, R = trIcx + 20, B = trIcy + 20;
  int X0 = (int)(L + (0 - L) * p + 0.5f),           Y0 = (int)(T + (0 - T) * p + 0.5f);
  int X1 = (int)(R + (SCR_W - R) * p + 0.5f),       Y1 = (int)(B + (SCR_H - B) * p + 0.5f);
  int rad = (int)(12.0f * (1.0f - p) + 0.5f);
  float wa = p * 5.0f; if (wa > 1) wa = 1;
  blitScaled(win, X0, Y0, X1, Y1, rad, (uint8_t)(255.0f * wa));
}
static void trSlide(const u16* A, const u16* B, float p) {      // B masuk dari kanan, A bergeser pelan di belakangnya
  int o = (int)(SCR_W * (1.0f - p) + 0.5f); if (o < 0) o = 0; if (o > SCR_W) o = SCR_W;
  int s = (int)((SCR_W - o) * 0.30f);
  uint32_t k = (uint32_t)(255 - (int)(70.0f * p)) * 32 / 255;
  for (int y = 0; y < SCR_H; y++) {
    u16* d = fb + y * SCR_W;
    if (o > 0)      { memcpy(d, A + y * SCR_W + s, (size_t)o * 2); if (k < 32) dimSpan(d, o, k); }
    if (o < SCR_W)  memcpy(d + o, B + y * SCR_W, (size_t)(SCR_W - o) * 2);
  }
  if (o < SCR_W - 2) {                                           // bayangan lembut di tepi kiri layar yang masuk
    for (int dx = 1; dx <= 10; dx++) {
      int x = o - dx; if (x < 0) break;
      uint8_t a = (uint8_t)((11 - dx) * 7);
      for (int y = 0; y < SCR_H; y++) { u16* q = fb + y * SCR_W + x; *q = mix(0x0000, *q, a); }
    }
  }
}
static void trFade(const u16* A, const u16* B, float p) {
  uint8_t a = (uint8_t)(255.0f * clamp01(p));
  for (int i = 0; i < SCR_W * SCR_H; i++) fb[i] = mix(B[i], A[i], a);
}
// gambar satu frame transisi ke fb; false = transisi selesai (frame terakhir = layar baru)
static bool trFrame(uint32_t now) {
  uint32_t el = now - trT0;
  bool more = el < trDur;
  float t = more ? (float)el / (float)trDur : 1.0f;
  float e = easeUI(t);
  switch (trKind) {
    case TR_ZOOM_OPEN:  trZoom(snapBuf, snapBuf2, e); break;
    case TR_ZOOM_CLOSE: trZoom(snapBuf2, snapBuf, 1.0f - e); break;
    case TR_SLIDE_FWD:  trSlide(snapBuf, snapBuf2, e); break;
    case TR_SLIDE_BACK: trSlide(snapBuf2, snapBuf, 1.0f - e); break;
    default:            trFade(snapBuf, snapBuf2, smooth(t)); break;
  }
  return more;
}


// ============================== DAFTAR TOMBOL ================================
static Btn& addBtn(int x, int y, int w, int h, int code, uint8_t style, const char* label = "", const char* sub = "",
                   const AIcon* icon = nullptr, u16 ink = 0xFFFF) {
  if (nbtn >= 56) nbtn = 55;
  Btn& b = btns[nbtn++];
  b.x = x; b.y = y; b.w = w; b.h = h; b.code = code; b.style = style; b.icon = icon; b.ink = ink;
  strncpy(b.label, label, sizeof(b.label) - 1); b.label[sizeof(b.label) - 1] = 0;
  strncpy(b.sub, sub, sizeof(b.sub) - 1);       b.sub[sizeof(b.sub) - 1] = 0;
  return b;
}
static int hitBtn(int x, int y) {
  for (int i = nbtn - 1; i >= 0; i--) {
    const Btn& b = btns[i];
    if (x >= b.x - 2 && x < b.x + b.w + 2 && y >= b.y - 2 && y < b.y + b.h + 2) return i;
  }
  return -1;
}

// riak sentuhan: lingkaran membesar dari titik sentuh, terpotong mengikuti bentuk tombol
static void drawRipple(int idx, float x, float y, float w, float h, float rad) {
  if (!rip.on || rip.bi != idx) return;
  uint32_t el = millis() - rip.t0;
  if (el > 420) return;
  float t = el / 420.0f;
  float R = 8.0f + sqrtf(w * w + h * h) * easeOut(t);
  float amax = 70.0f * (1.0f - t);
  float cx = x + w * 0.5f, cy = y + h * 0.5f, hw = w * 0.5f, hh = h * 0.5f;
  float r = rad; if (r > hw) r = hw; if (r > hh) r = hh;
  float ax = hw - r, ay = hh - r;
  int xa = (int)fmaxf(x, rip.x - R), xb = (int)fminf(x + w, rip.x + R) + 1;
  int ya = (int)fmaxf(y, rip.y - R), yb = (int)fminf(y + h, rip.y + R) + 1;
  float R2 = R * R;
  for (int j = ya; j < yb; j++) for (int i = xa; i < xb; i++) {
    float dx = i + 0.5f - rip.x, dy = j + 0.5f - rip.y, d2 = dx * dx + dy * dy;
    if (d2 > R2) continue;
    float cv = rrCov(i + 0.5f, j + 0.5f, cx, cy, ax, ay, r, 0);
    if (cv <= 0) continue;
    float edge = R - sqrtf(d2); float e = edge > 3 ? 1.0f : edge / 3.0f;
    px(i, j, 0xFFFF, (uint8_t)(amax * cv * e));
  }
}

// pv = pegas tekan (0 lepas, 1 tertekan, bisa sedikit <0 / >1 saat memantul)
static void drawBtn(const Btn& b, bool pr, float pv, int idx) {
  (void)pr;
  const Theme& t = THEMES[curTheme];
  float x = b.x, y = b.y, w = b.w, h = b.h;
  float pc = clamp01(pv);
  switch (b.style) {
    case B_HIDDEN: return;
    case B_APP: {
      const App& a = APPS[b.code];
      float cx = x + w / 2, cy = y + 22;
      float s = 40.0f - 7.0f * pv;                                   // mengecil saat ditekan, memantul saat dilepas
      if (pc > 0.03f) glow((int)cx, (int)cy, 36, a.ink, (uint8_t)(48.0f * pc));
      u16 tile = pc > 0.01f ? mix(H(0xFFFFFF), a.tile, (uint8_t)(34.0f * pc)) : a.tile;
      u16 edge = pc > 0.01f ? mix(a.ink, a.edge, (uint8_t)(110.0f * pc)) : a.edge;
      rrect(cx - s / 2, cy - s / 2, s, s, 12, tile);
      rrect(cx - s / 2 + 0.5f, cy - s / 2 + 0.5f, s - 1, s - 1, 11.5f, edge, 255, 1.0f);
      drawIcon(*a.ic, cx, cy, a.ink, (uint8_t)(255.0f - 40.0f * pc));
      drawText(F9, (int)cx, (int)cy + 33, a.name, pc > 0.01f ? mix(COL_WHITE, COL_LABEL, (uint8_t)(255.0f * pc)) : COL_LABEL, 255, 1);
      if (pc > 0.1f) disc(cx, cy + 41, 1.7f, a.ink, (uint8_t)(255.0f * pc));   // titik penanda "akan dibuka"
      return;
    }
    case B_ROW: {
      rrect(x, y, w, h, 12, H(0xFFFFFF), (uint8_t)(14.0f + 20.0f * pc));
      rrect(x + 0.5f, y + 0.5f, w - 1, h - 1, 11.5f, H(0xFFFFFF), (uint8_t)(24.0f + 30.0f * pc), 1.0f);
      drawRipple(idx, x, y, w, h, 12);
      if (pc > 0.05f) rrect(x + 2.5f, y + h * 0.5f - 8.0f * pc, 2.6f, 16.0f * pc, 1.3f, t.accent, (uint8_t)(230.0f * pc));   // penanda aksen di kiri
      int tx0 = (int)x + 14;
      if (b.icon) {
        rrect(x + 8, y + (h - 30) / 2, 30, 30, 9, H(0x1B222C));
        drawIcon(*b.icon, x + 23, y + h / 2, b.ink);
        tx0 = (int)x + 48;
      }
      bool two = b.sub[0] != 0 && h >= 30;               // baris pendek: keterangan di kanan, satu baris
      drawText(F10, tx0, (int)(y + h / 2) + (two ? -2 : 4), b.label, COL_TEXT);
      if (two) drawText(F8, tx0, (int)(y + h / 2) + 12, b.sub, COL_MUTED);
      else if (b.sub[0]) drawText(F8, (int)(x + w - 26), (int)(y + h / 2) + 4, b.sub, COL_MUTED, 255, 2);
      drawIcon(IC_CHEV_R, x + w - 14 + 3.0f * pc, y + h / 2, pc > 0.3f ? t.accent : COL_MUTED2);   // panah bergeser = "akan dibuka"
      return;
    }
    default: break;
  }
  // tombol berisi (kalkulator, keyboard, dll)
  u16 fill, ink = COL_WHITE;
  switch (b.style) {
    case B_KEY:  fill = H(0x1B222C); break;
    case B_KEY2: fill = H(0x303946); break;
    case B_OP:   fill = mix(t.accent, H(0x0F141B), 70); ink = t.accent; break;
    case B_EQ:   fill = t.accent; ink = H(0x07201C); break;
    case B_KB:   fill = H(0x232B36); break;
    default:     fill = H(0x363F4D); break;   // B_KBSP
  }
  if (pc > 0.01f) fill = mix(H(0xFFFFFF), fill, (uint8_t)(60.0f * pc));
  float rad = h * 0.5f; if (rad > 11) rad = 11;
  float in = 1.4f * pv;                                              // tombol mengecil sedikit saat ditekan
  rrect(x + in, y + in, w - 2 * in, h - 2 * in, rad, fill);
  drawRipple(idx, x, y, w, h, rad);
  bool kb = (b.style == B_KB || b.style == B_KBSP);
  if (b.icon) drawIcon(*b.icon, x + w * 0.5f, y + h * 0.5f, ink);
  else if (b.label[0]) drawText(kb ? F10 : B13, (int)(x + w * 0.5f), (int)(y + h * 0.5f) + (kb ? 4 : 5), b.label, ink, 255, 1);
}

// ============================== KALKULATOR ===================================
static char   calcDisp[24] = "0";
static char   calcExpr[28] = "";
static double calcAcc = 0;
static char   calcOp = 0;
static bool   calcFresh = true, calcErr = false;

static void calcReset() { strcpy(calcDisp, "0"); calcExpr[0] = 0; calcAcc = 0; calcOp = 0; calcFresh = true; calcErr = false; }
static double calcVal() { return atof(calcDisp); }
static void calcSetNum(double v) {
  if (isnan(v) || isinf(v)) { strcpy(calcDisp, "Error"); calcErr = true; return; }
  char buf[32]; snprintf(buf, sizeof(buf), "%.9g", v);
  if (strlen(buf) > 13) snprintf(buf, sizeof(buf), "%.6g", v);
  if (!strcmp(buf, "-0")) strcpy(buf, "0");
  strncpy(calcDisp, buf, sizeof(calcDisp) - 1); calcDisp[sizeof(calcDisp) - 1] = 0;
}
static double calcApply(double a, char op, double b) {
  switch (op) { case '+': return a + b; case '-': return a - b; case '*': return a * b; case '/': return b == 0 ? NAN : a / b; }
  return b;
}
static void calcPress(int code) {
  if (code == 'C') { calcReset(); return; }
  if (calcErr) return;
  if (code >= '0' && code <= '9') {
    if (calcFresh) { strcpy(calcDisp, "0"); calcFresh = false; }
    int n = strlen(calcDisp);
    if (!strcmp(calcDisp, "0")) { calcDisp[0] = code; calcDisp[1] = 0; }
    else if (!strcmp(calcDisp, "-0")) { calcDisp[1] = code; calcDisp[2] = 0; }
    else if (n < 12) { calcDisp[n] = code; calcDisp[n + 1] = 0; }
  } else if (code == '.') {
    if (calcFresh) { strcpy(calcDisp, "0"); calcFresh = false; }
    if (!strchr(calcDisp, '.') && strlen(calcDisp) < 12) strcat(calcDisp, ".");
  } else if (code == 'n') {
    if (strcmp(calcDisp, "0")) {
      if (calcDisp[0] == '-') memmove(calcDisp, calcDisp + 1, strlen(calcDisp));
      else { memmove(calcDisp + 1, calcDisp, strlen(calcDisp) + 1); calcDisp[0] = '-'; }
    }
  } else if (code == '%') {
    calcSetNum(calcVal() / 100.0); calcFresh = true;
  } else if (code == '=') {
    if (calcOp) { double r = calcApply(calcAcc, calcOp, calcVal()); calcExpr[0] = 0; calcOp = 0; calcSetNum(r); calcFresh = true; }
  } else {                                   // + - * /
    if (calcOp && !calcFresh) { double r = calcApply(calcAcc, calcOp, calcVal()); calcSetNum(r); if (calcErr) return; }
    calcAcc = calcVal(); calcOp = (char)code; calcFresh = true;
    snprintf(calcExpr, sizeof(calcExpr), "%s %c", calcDisp, code == '*' ? 'x' : (char)code);
  }
}

// ============================== CATATAN & BERKAS (LittleFS) ==================
static char noteText[184]; static int noteLen = 0, noteSlot = 0;
static int  kbLayer = 0;                        // 0 huruf kecil, 1 huruf besar, 2 simbol

static void notePath(int n, char* out) { snprintf(out, 24, "/catatan%d.txt", n + 1); }
static void loadNote(int n) {
  noteLen = 0; noteText[0] = 0;
  if (!fsOK) return;
  char path[24]; notePath(n, path);
  File f = LittleFS.open(path, "r");
  if (f) { noteLen = f.readBytes(noteText, sizeof(noteText) - 1); noteText[noteLen] = 0; f.close(); }
}
static void saveNote() {
  if (!fsOK) return;
  char path[24]; notePath(noteSlot, path);
  if (noteLen == 0) { LittleFS.remove(path); return; }
  File f = LittleFS.open(path, "w");
  if (f) { f.write((const uint8_t*)noteText, noteLen); f.close(); }
}
static void notePreview(int n, char* out, int maxc) {
  out[0] = 0;
  if (!fsOK) { strncpy(out, "Penyimpanan tidak tersedia", maxc); out[maxc] = 0; return; }
  char path[24]; notePath(n, path);
  File f = LittleFS.open(path, "r");
  if (!f) { strcpy(out, "Kosong"); return; }
  int i = 0; while (i < maxc && f.available()) { int c = f.read(); if (c == '\n' || c == '\r') break; out[i++] = (char)c; }
  out[i] = 0; f.close();
  if (!i) strcpy(out, "Kosong");
}

static char fNames[24][24]; static uint32_t fSizes[24]; static int fCount = 0, fPage = 0;
static char viewName[24], viewBuf[420]; static int viewLen = 0; static bool viewBinary = false;

static void refreshFiles() {
  fCount = 0;
  if (!fsOK) return;
  File root = LittleFS.open("/");
  if (!root) return;
  File f = root.openNextFile();
  while (f && fCount < 24) {
    if (!f.isDirectory()) {
      const char* nm = f.name(); if (nm[0] == '/') nm++;
      strncpy(fNames[fCount], nm, 23); fNames[fCount][23] = 0;
      fSizes[fCount] = f.size(); fCount++;
    }
    f = root.openNextFile();
  }
  if (fPage * 4 >= fCount) fPage = 0;
}
static void openFileView(const char* name) {
  strncpy(viewName, name, 23); viewName[23] = 0;
  viewLen = 0; viewBinary = false; viewBuf[0] = 0;
  char path[32]; snprintf(path, sizeof(path), "/%s", name);
  File f = LittleFS.open(path, "r");
  if (!f) return;
  viewLen = f.readBytes(viewBuf, sizeof(viewBuf) - 1); viewBuf[viewLen] = 0; f.close();
  for (int i = 0; i < viewLen; i++) { uint8_t c = viewBuf[i]; if ((c < 32 && c != '\n' && c != '\r' && c != '\t') || c > 126) { viewBinary = true; break; } }
}
static void fmtSize(uint32_t b, char* out) {
  if (b < 1024) snprintf(out, 16, "%u B", (unsigned)b);
  else if (b < 1024 * 1024) snprintf(out, 16, "%.1f KB", b / 1024.0f);
  else snprintf(out, 16, "%.2f MB", b / 1048576.0f);
}

// ============================== STOPWATCH & SETELAN ==========================
static bool swRunning = false; static uint32_t swStart = 0, swAcc = 0;
static uint32_t swElapsed() { return swAcc + (swRunning ? millis() - swStart : 0); }

// ============================== BANGUN TOMBOL PER LAYAR ======================
static void buildKeyboard() {
  static const char* L0[3] = {"qwertyuiop", "asdfghjkl", "zxcvbnm"};
  static const char* L1[3] = {"QWERTYUIOP", "ASDFGHJKL", "ZXCVBNM"};
  static const char* L2[3] = {"1234567890", "-/:;()$&@", ".,?!'\"%"};
  const char** L = kbLayer == 0 ? L0 : (kbLayer == 1 ? L1 : L2);
  char lb[2] = {0, 0};
  int y0 = 168, kh = 26;
  for (int i = 0; i < 10; i++) { lb[0] = L[0][i]; addBtn(11 + i * 22, y0, 20, kh, L[0][i], B_KB, lb); }
  for (int i = 0; i < 9; i++)  { lb[0] = L[1][i]; addBtn(22 + i * 22, y0 + 30, 20, kh, L[1][i], B_KB, lb); }
  if (kbLayer == 2) addBtn(13, y0 + 60, 29, kh, '#', B_KBSP, "#");
  else addBtn(13, y0 + 60, 29, kh, -1, B_KBSP, "", "", &IC_SHIFT);
  for (int i = 0; i < 7; i++)  { lb[0] = L[2][i]; addBtn(44 + i * 22, y0 + 60, 20, kh, L[2][i], B_KB, lb); }
  addBtn(198, y0 + 60, 29, kh, -2, B_KBSP, "", "", &IC_BKSP);
  addBtn(12, y0 + 90, 40, kh, -3, B_KBSP, kbLayer == 2 ? "abc" : "?123");
  addBtn(54, y0 + 90, 22, kh, ',', B_KB, ",");
  addBtn(78, y0 + 90, 84, kh, ' ', B_KB, "");
  addBtn(164, y0 + 90, 22, kh, '.', B_KB, ".");
  addBtn(188, y0 + 90, 40, kh, -4, B_KBSP, "Enter");
}

// Keyboard ala HP modern: baris angka, QWERTY, Shift (ketuk 2x = Caps Lock), ?123 + halaman simbol
static void buildPhoneKeyboard() {
  static const char* LL[3] = {"qwertyuiop", "asdfghjkl", "zxcvbnm"};
  static const char* LU[3] = {"QWERTYUIOP", "ASDFGHJKL", "ZXCVBNM"};
  static const char* S1[3] = {"!@#$%^&*()", "-_=+[]{}|", ";:'\"/?`"};
  static const char* S2[3] = {"~`\\|<>[]{}", "#%^&*+=_-", "$@!?;:/"};
  const char* const* L = (kbL == 0) ? LL : (kbL <= 2) ? LU : (kbL == 3) ? S1 : S2;
  bool sym = kbL >= 3;
  const int y0 = 146, kh = 24, pt = 28;
  char lb[2] = {0, 0};
  for (int i = 0; i < 10; i++) { lb[0] = "1234567890"[i]; addBtn(6 + i * 23, y0, 21, kh, lb[0], B_KB, lb); }
  for (int i = 0; i < 10; i++) { lb[0] = L[0][i]; addBtn(6 + i * 23,  y0 + pt,     21, kh, lb[0], B_KB, lb); }
  for (int i = 0; i < 9;  i++) { lb[0] = L[1][i]; addBtn(17 + i * 23, y0 + 2 * pt, 21, kh, lb[0], B_KB, lb); }
  if (sym) addBtn(6, y0 + 3 * pt, 31, kh, -1, B_KBSP, kbL == 3 ? "=\\<" : "?123");
  else     addBtn(6, y0 + 3 * pt, 31, kh, -1, kbL == 1 ? B_OP : (kbL == 2 ? B_EQ : B_KBSP), "", "", &IC_SHIFT);
  for (int i = 0; i < 7; i++) { lb[0] = L[2][i]; addBtn(40 + i * 23, y0 + 3 * pt, 21, kh, lb[0], B_KB, lb); }
  addBtn(202, y0 + 3 * pt, 32, kh, -2, B_KBSP, "", "", &IC_BKSP);
  addBtn(6,   y0 + 4 * pt, 34, kh, -3, B_KBSP, sym ? "abc" : "?123");
  addBtn(43,  y0 + 4 * pt, 22, kh, ',', B_KB, ",");
  addBtn(68,  y0 + 4 * pt, 96, kh, ' ', B_KB, "");
  addBtn(167, y0 + 4 * pt, 22, kh, '.', B_KB, ".");
  addBtn(192, y0 + 4 * pt, 42, kh, -4, B_EQ, "Go");
}

static void buildButtons() {
  nbtn = 0; pressedId = -1;
  memset(bpX, 0, sizeof(bpX)); memset(bpV, 0, sizeof(bpV)); rip.on = false;
  char sub[32], num[16];
  switch (screen) {
    case SC_HOME:
      for (int i = 0; i < 6; i++) {                         // tombol hanya untuk halaman aktif (posisi diam)
        int app = homePage * 6 + i; if (app >= APP_COUNT) break;
        addBtn(COLX[i % 3] - 34, ROWY[i / 3] - 22, 68, 62, app, B_APP, APPS[app].name);
      }
      break;
    case SC_CALC: {
      static const char* LB[20] = {"C","+/-","%","/", "7","8","9","*", "4","5","6","-", "1","2","3","+", "0","","." ,"="};
      static const int   CD[20] = {'C','n','%','/', '7','8','9','*', '4','5','6','-', '1','2','3','+', '0',0,'.','='};
      for (int r = 0; r < 5; r++) for (int c = 0; c < 4; c++) {
        int k = r * 4 + c; if (r == 4 && c == 1) continue;
        int x = 12 + c * 55, y = 128 + r * 32, w = 51;
        if (r == 4 && c == 0) w = 106;
        uint8_t st = B_KEY; const AIcon* ic = nullptr;
        if (r == 0 && c < 3) st = B_KEY2;
        if (c == 3) st = B_OP;
        if (r == 4 && c == 3) st = B_EQ;
        if (CD[k] == '*') ic = &IC_MUL; if (CD[k] == '/') ic = &IC_DIV;
        addBtn(x, y, w, 28, CD[k], st, LB[k], "", ic);
      }
      break;
    }
    case SC_NOTES:
      for (int i = 0; i < 4; i++) { char pv[28]; notePreview(i, pv, 26); snprintf(sub, sizeof(sub), "%s", pv); char nm[16]; snprintf(nm, sizeof(nm), "Catatan %d", i + 1); addBtn(12, 66 + i * 52, 216, 46, i + 1, B_ROW, nm, sub, &IC_NOTES, H(0x8CC8FF)); }
      break;
    case SC_NOTEEDIT:
      addBtn(174, 38, 54, 24, 200, B_KEY2, "Hapus");
      buildKeyboard();
      break;
    case SC_FILES: {
      addBtn(166, 38, 28, 24, 90, B_KEY2, "<");
      addBtn(198, 38, 28, 24, 91, B_KEY2, ">");
      for (int i = 0; i < 4; i++) {
        int idx = fPage * 4 + i; if (idx >= fCount) break;
        fmtSize(fSizes[idx], num);
        addBtn(12, 108 + i * 44, 216, 40, 10 + i, B_ROW, fNames[idx], num, &IC_FOLDER, H(0xF4C24E));
      }
      break;
    }
    case SC_FILEVIEW:
      addBtn(12, 248, 100, 32, 50, B_KEY2, "Hapus berkas");
      break;
    case SC_STOPWATCH:
      addBtn(12, 236, 104, 38, 1, swRunning ? B_KEY2 : B_EQ, swRunning ? "Berhenti" : "Mulai");
      addBtn(124, 236, 104, 38, 2, B_KEY, "Reset");
      break;
    case SC_SETTINGS: {
      static const char* LKN[3] = {"Mati", "PIN", "Pola"};
      addBtn(12, 66, 216, 26, 2, B_ROW, "Tema", THEMES[curTheme].name);
      snprintf(sub, sizeof(sub), "%02d:%02d", clk_hh, clk_mm);
      addBtn(12, 93, 216, 26, 3, B_ROW, "Atur jam & tanggal", sub);
      addBtn(12, 120, 216, 26, 7, B_ROW, "Kunci layar", LKN[lkType > 2 ? 0 : lkType]);
      addBtn(12, 147, 216, 26, 8, B_ROW, "Info sistem");
      addBtn(12, 174, 216, 26, 4, B_ROW, "Kalibrasi touch");
      addBtn(12, 201, 216, 26, 5, B_ROW, "Matikan layar");
      addBtn(12, 228, 216, 26, 6, B_ROW, "Tentang espOS");
      addBtn(12, 255, 216, 26, 9, B_ROW, "Update espOS");
      break;
    }
    case SC_OTA:
      addBtn(12, 100, 216, 48, 1, B_ROW, "Cek update", ota::labels[ota::state.load()]);
      break;
    case SC_LOCKSET:
      addBtn(12, 70,  216, 44, 1, B_ROW, "Tanpa kunci", lkType == 0 ? "Aktif" : "Geser ke atas langsung buka");
      addBtn(12, 120, 216, 44, 2, B_ROW, "PIN", lkType == 1 ? "Aktif - 4 sampai 8 angka" : "4 sampai 8 angka");
      addBtn(12, 170, 216, 44, 3, B_ROW, "Pola", lkType == 2 ? "Aktif - 9 titik" : "Gambar pola di 9 titik");
      break;
    case SC_SETTIME:
      for (int f = 0; f < 5; f++) {
        addBtn(132, 70 + f * 42, 42, 32, f * 2,     B_KEY2, "-");
        addBtn(182, 70 + f * 42, 42, 32, f * 2 + 1, B_KEY2, "+");
      }
      break;
    case SC_WIFI:
      addBtn(168, 36, 66, 28, 1, B_HIDDEN);            // saklar Wi-Fi
      addBtn(134, 66, 36, 18, 90, B_HIDDEN);           // halaman sebelumnya
      addBtn(200, 66, 36, 18, 91, B_HIDDEN);           // halaman berikutnya
      for (int i = 0; i < 5; i++) addBtn(12, 84 + i * 40, 216, 36, 10 + i, B_HIDDEN);   // baris jaringan
      break;
    case SC_WIFIPASS:
      addBtn(170, 78, 58, 30, 201, B_HIDDEN);          // lihat / sembunyikan password
      addBtn(12, 114, 216, 26, 202, B_HIDDEN);         // tombol Sambung
      buildPhoneKeyboard();
      break;
    case SC_RECENTS: {
      int y = 66;
      for (int i = 0; i < 4; i++) {
        if (recents[i] < 0) break;
        const App& a = APPS[recents[i]];
        addBtn(12, y, 216, 42, i, B_ROW, a.name, "Ketuk untuk membuka", a.ic, a.ink); y += 46;
      }
      if (recents[0] >= 0) addBtn(12, 256, 216, 26, 99, B_KEY2, "Tutup semua");
      break;
    }
    default: break;
  }
}

static void drawScene();   // deklarasi maju (dipakai untuk cuplikan transisi)

static int appOfScreen(Screen s) {            // layar ini milik aplikasi nomor berapa di beranda (-1 = bukan)
  switch (s) {
    case SC_FILES: case SC_FILEVIEW: return 0;
    case SC_CALC: return 1;
    case SC_NOTES: case SC_NOTEEDIT: return 2;
    case SC_STOPWATCH: return 3;
    case SC_DINO: return 6;
    case SC_PONG: return 7;
    case SC_FLAPPY: return 8;
    case SC_SETTINGS: case SC_SYSINFO: case SC_SETTIME: case SC_OTA: case SC_ABOUT: case SC_WIFI: case SC_WIFIPASS:
    case SC_LOCKSET: case SC_PINPAD: case SC_PATTERN: return 5;
    default: return -1;
  }
}
static int screenDepth(Screen s) {            // kedalaman layar di dalam aplikasi (untuk arah geser)
  switch (s) {
    case SC_HOME: return 0;
    case SC_NOTEEDIT: case SC_FILEVIEW: case SC_SYSINFO: case SC_SETTIME: case SC_OTA: case SC_ABOUT: case SC_LOCKSET: case SC_WIFIPASS: return 2;
    case SC_PINPAD: case SC_PATTERN: return 3;
    default: return 1;
  }
}

static void goScreen(Screen s) {
  Screen old = screen;
  uint8_t kind = TR_NONE; uint16_t dur = 0; int iconApp = -1;
  if (trActive) trActive = false;
  if (trReady() && s != old && !locked && !sleeping && !sheetOpen && !cpOpen && cpAnim < 0.02f) {
    int ao = appOfScreen(old), an = appOfScreen(s);
    kind = TR_FADE; dur = 170;
    if (old == SC_HOME && an >= 0)         { kind = TR_ZOOM_OPEN;  dur = 340; iconApp = an; }
    else if (s == SC_HOME && ao >= 0)      { kind = TR_ZOOM_CLOSE; dur = 300; iconApp = ao; }
    else if (ao >= 0 && ao == an) {
      int d0 = screenDepth(old), d1 = screenDepth(s);
      if (d1 > d0) { kind = TR_SLIDE_FWD; dur = 270; } else if (d1 < d0) { kind = TR_SLIDE_BACK; dur = 250; }
    }
    rip.on = false;
    u16* keep = fb; fb = snapBuf; drawScene(); fb = keep;       // cuplikan layar LAMA (langsung ke snapBuf)
  }
  if (s == SC_HOME) { int aoo = appOfScreen(old); if (aoo >= 0) { homePage = aoo / 6; homePos = (float)(homePage * 240); homeV = 0; homeSpring = false; } }
  screen = s; sheetOpen = false;
  if (s == SC_FILES) refreshFiles();
  if (s == SC_PINPAD || s == SC_PATTERN) credReset();
  buildButtons(); dirty = true;
  if (kind != TR_NONE) {
    u16* keep = fb; fb = snapBuf2; drawScene(); fb = keep;      // cuplikan layar BARU
    if (iconApp >= 0) { int ii = iconApp % 6; trIcx = COLX[ii % 3]; trIcy = ROWY[ii / 3]; }
    trBegin(kind, dur);
  }
}
static void pushRecent(int app) {
  int j = 0; int8_t tmp[4] = {-1, -1, -1, -1}; tmp[j++] = app;
  for (int i = 0; i < 4 && j < 4; i++) if (recents[i] >= 0 && recents[i] != app) tmp[j++] = recents[i];
  for (int i = 0; i < 4; i++) recents[i] = tmp[i];
}
static void openApp(int a) {
  if (a == 4) { sheetOpen = true; lastAnimMs = millis(); dirty = true; return; }
  pushRecent(a);
  switch (a) {
    case 0: fPage = 0; goScreen(SC_FILES); break;
    case 1: goScreen(SC_CALC); break;
    case 2: goScreen(SC_NOTES); break;
    case 3: goScreen(SC_STOPWATCH); break;
    case 5: goScreen(SC_SETTINGS); break;
    case 6: gameStart(SC_DINO);   goScreen(SC_DINO);   break;
    case 7: gameStart(SC_PONG);   goScreen(SC_PONG);   break;
    case 8: gameStart(SC_FLAPPY); goScreen(SC_FLAPPY); break;
  }
}

// ============================== KOMPONEN TAMPILAN ============================
// beranda: dua halaman bergulir mengikuti homePos, titik halaman di bawah
static void drawHomePages() {
  const Theme& t = THEMES[curTheme];
  int p0 = (int)floorf(homePos / (float)SCR_W);
  for (int p = p0; p <= p0 + 1; p++) {
    if (p < 0 || p >= HOME_PAGES) continue;
    int ox = (int)floorf(p * (float)SCR_W - homePos + 0.5f);
    for (int i = 0; i < 6; i++) {
      int app = p * 6 + i; if (app >= APP_COUNT) break;
      Btn b; memset(&b, 0, sizeof(b));
      b.x = COLX[i % 3] - 34 + ox; b.y = ROWY[i / 3] - 22; b.w = 68; b.h = 62; b.code = app; b.style = B_APP;
      float pv = 0; int idx = -1;
      if (p == homePage && i < nbtn && btns[i].code == app) { pv = bpX[i]; idx = i; }
      if (b.x + b.w < 0 || b.x > SCR_W) continue;
      drawBtn(b, false, pv, idx);
    }
  }
  float prog = homePos / (float)SCR_W;
  for (int i = 0; i < HOME_PAGES; i++) {
    float near = 1.0f - fabsf(prog - (float)i); if (near < 0) near = 0;
    float cx = 120.0f + (i - (HOME_PAGES - 1) * 0.5f) * 14.0f;
    disc(cx, 279, 2.2f + 0.8f * near, near > 0.5f ? t.accent : COL_MUTED2, (uint8_t)(90 + 165 * near));
  }
}

static void drawStatusIcons(int oy) {
  const Theme& t = THEMES[curTheme];
  if (wifiSt == WF_ON) drawIcon(IC_WIFI, 181, oy + 15, COL_TEXT);          // hanya tampil saat Wi-Fi terhubung
  rrect(199, oy + 10, 22, 10.5f, 3.2f, H(0x7E8896), 255, 1.2f);
  rrect(201.5f, oy + 12.5f, 17.0f * BATT_PERCENT / 100.0f, 5.5f, 1.6f, t.accent);
  rrect(221.4f, oy + 12.8f, 2.2f, 4.6f, 1.0f, H(0x7E8896));
}
static void drawStatusBar() {
  drawText(B9, 16, 18, "espOS", COL_TEXT);
  drawStatusIcons(0);
}

static void drawHomeTop() {
  char buf[40];
  snprintf(buf, sizeof(buf), "Halo, %s.", USER_NAME);
  drawText(F10, 16, 43, buf, COL_MUTED);
  snprintf(buf, sizeof(buf), "%02d:%02d", clk_hh, clk_mm);
  drawText(CLK, 13, 92, buf, COL_WHITE);
  snprintf(buf, sizeof(buf), "%s, %d %s %d", HARI[clk_wd], clk_dd, BULAN[clk_mo], clk_yy);
  drawText(F10, 17, 110, buf, COL_MUTED);
}

static void drawNav(u16 ink, uint8_t dark) {
  if (dark) dimRows(NAV_Y, SCR_H, dark);
  for (int i = 0; i < 3; i++) {
    float pc = clamp01(navSp[i]);
    if (pc > 0.02f) disc(NAVX[i], 304, 8.0f + 8.0f * navSp[i], ink, (uint8_t)(44.0f * pc));
  }
  drawIcon(IC_NAV_BACK,   NAVX[0], 304, ink);
  drawIcon(IC_NAV_HOME,   NAVX[1], 304, ink);
  drawIcon(IC_NAV_RECENT, NAVX[2], 304, ink);
}

static void drawThemeDisc(float cx, float cy, float r, const Theme& t) {
  int x0 = (int)(cx - r - 1), x1 = (int)(cx + r + 2), y0 = (int)(cy - r - 1), y1 = (int)(cy + r + 2);
  float acx = cx + r * 0.95f, acy = cy + r * 0.25f, ar = r * 1.15f;
  for (int j = y0; j < y1; j++) for (int i = x0; i < x1; i++) {
    float dx = i + 0.5f - cx, dy = j + 0.5f - cy, d = sqrtf(dx * dx + dy * dy);
    float cov = r - d + 0.5f; if (cov <= 0) continue; if (cov > 1) cov = 1;
    float lit = 0.30f * (1.0f - d / r) * (1.0f - d / r) + 0.06f;
    float ex = i + 0.5f - acx, ey = j + 0.5f - acy;
    float s = fabsf(sqrtf(ex * ex + ey * ey) - ar) / (r * 0.13f);
    float streak = s < 1 ? (1 - s) * 0.75f : 0;
    float k = lit + streak; if (k > 1) k = 1;
    px(i, j, mix(t.discHi, t.discBase, (uint8_t)(k * 255)), (uint8_t)(cov * 255));
  }
}

static void drawSheet() {
  float p = sheetAnim;
  if (p <= 0.002f) return;
  if (p > 1.06f) p = 1.06f;
  const Theme& t = THEMES[curTheme];
  int top = SCR_H - (int)(135.0f * p + 0.5f);
  dimRows(0, top, (uint8_t)(120.0f * clamp01(p)));
  rrect(0, top, SCR_W, 200, 18, H(0x0F1520));
  rrect(0.5f, top + 0.5f, SCR_W - 1, 200, 17.5f, H(0x232E3F), 255, 1.0f);
  rrect(110, top + 5, 20, 3, 1.5f, H(0x39445A));
  drawText(B13, 17, top + 28, "Pilih tema", COL_TEXT);
  drawIcon(IC_CLOSE, 218, top + 24, COL_MUTED);
  drawText(F9, 17, top + 45, "Warna untuk harimu.", COL_MUTED);
  static const int DX[3] = {50, 120, 190};
  int cy = top + 85;
  for (int i = 0; i < 3; i++) {
    bool sel = (i == curTheme);
    if (sel) { ringS(DX[i], cy, 22.0f, 2.0f, t.accent); drawThemeDisc(DX[i], cy, 18.0f, THEMES[i]); }
    else drawThemeDisc(DX[i], cy, 17.0f, THEMES[i]);
    if (sel) {
      disc(DX[i] + 14, cy + 15, 7.5f, H(0x0F1520));
      disc(DX[i] + 14, cy + 15, 6.2f, t.accent);
      drawIcon(IC_CHECK, DX[i] + 14, cy + 15, H(0x07201C));
      drawText(B9, DX[i], top + 119, THEMES[i].name, COL_WHITE, 255, 1);
    } else drawText(F9, DX[i], top + 119, THEMES[i].name, COL_MUTED, 255, 1);
  }
}

// ============================== CONTROL PANEL & LOCK SCREEN ==================
static u16 flashCol565(int i) { return H(((uint32_t)FL_RGB[i][0] << 16) | ((uint32_t)FL_RGB[i][1] << 8) | FL_RGB[i][2]); }

// ikon vektor kecil untuk tile (bg = warna isi tile, dipakai untuk "melubangi" bentuk)
static void cpIcon(int id, float cx, float cy, u16 c, u16 bg) {
  switch (id) {
    case 0: {                                           // Wi-Fi
      float by = cy + 8;
      arcLine(cx, by, 5.0f,  2.2f, 225, 315, c, 255);
      arcLine(cx, by, 10.0f, 2.2f, 225, 315, c, 255);
      arcLine(cx, by, 15.0f, 2.2f, 225, 315, c, 255);
      disc(cx, by, 2.0f, c);
      break;
    }
    case 1:                                             // senter
      rrect(cx - 7, cy - 14, 14, 7, 2.5f, c);
      rrect(cx - 4.5f, cy - 8, 9, 21, 3, c);
      disc(cx, cy + 1, 1.8f, bg);
      break;
    case 2:                                             // kunci
      ringS(cx, cy - 4, 5.5f, 2.2f, c);
      rrect(cx - 8, cy - 2, 16, 13, 3, c);
      disc(cx, cy + 4, 1.8f, bg);
      break;
    case 3:                                             // tidur (bulan sabit)
      disc(cx, cy, 10, c);
      disc(cx + 5, cy - 4, 8.5f, bg);
      break;
    case 4:                                             // deep sleep (ikon power)
      ringS(cx, cy + 1, 9.5f, 2.4f, c);
      rrect(cx - 4, cy - 13, 8, 10, 0, bg);
      rrect(cx - 1.3f, cy - 12, 2.6f, 12, 1.3f, c);
      break;
    default: drawIcon(IC_GEAR, cx, cy, c); break;       // setelan
  }
}

static void drawTile(int id, int x, int y, bool on, float pv, float hold, const char* label, const char* sub, u16 onCol, u16 onInk) {
  float pc = clamp01(pv);
  u16 fill = on ? onCol : H(0x1B222C);
  if (pc > 0.01f) fill = mix(H(0xFFFFFF), fill, (uint8_t)(55.0f * pc));
  u16 ink = on ? onInk : COL_TEXT;
  float in = 3.0f * pv;                                  // mengecil saat ditekan, memantul saat dilepas
  rrect(x + in, y + in, 68 - 2 * in, 64 - 2 * in, 16 - in * 0.5f, fill);
  if (!on) rrect(x + 0.5f + in, y + 0.5f + in, 67 - 2 * in, 63 - 2 * in, 15.5f - in * 0.5f, H(0xFFFFFF), 22, 1.0f);
  cpIcon(id, x + 34, y + 22, ink, fill);
  const AFont& lf = (textWidth(B9, label) <= 62) ? B9 : F9;
  drawText(lf, x + 34, y + (sub[0] ? 46 : 52), label, ink, 255, 1);
  if (sub[0]) drawText(F8, x + 34, y + 59, sub, on ? ink : COL_MUTED, 255, 1);
  if (hold > 0.02f) arcLine(x + 34, y + 32, 29.0f, 2.6f, 270.0f, 270.0f + 359.0f * hold, ink, 230);   // cincin progres "tahan"
}

static int cpHitTile(int x, int y) {                    // koordinat panel terbuka penuh
  static const int TX[3] = {12, 86, 160}, TYr[2] = {100, 170};
  for (int r = 0; r < 2; r++) for (int c = 0; c < 3; c++)
    if (x >= TX[c] && x < TX[c] + 68 && y >= TYr[r] && y < TYr[r] + 64) return r * 3 + c;
  return -1;
}

static void drawControlPanel() {
  float p = cpAnim;
  if (p <= 0.002f) return;
  if (p > 1.06f) p = 1.06f;
  const Theme& t = THEMES[curTheme];
  int oy = (int)(CP_H * p + 0.5f) - CP_H;
  int bot = oy + CP_H;
  float pc = clamp01(p);
  dimRows(bot, SCR_H, (uint8_t)(120.0f * pc));
  for (int k = 0; k < 9; k++) dimRows(bot + k, bot + k + 1, (uint8_t)((9 - k) * 6 * pc));   // bayangan lembut di bawah panel
  rrect(0, oy - 40, SCR_W, CP_H + 40, 20, H(0x0F1520));
  rrect(0.5f, oy - 40, SCR_W - 1, CP_H + 39.5f, 19.5f, H(0x232E3F), 255, 1.0f);

  char b[44];
  snprintf(b, sizeof(b), "%02d:%02d", clk_hh, clk_mm);
  drawText(B13, 16, oy + 30, b, COL_WHITE);
  snprintf(b, sizeof(b), "%s, %d %s %d", HARI[clk_wd], clk_dd, BULAN[clk_mo], clk_yy);
  drawText(F9, 16, oy + 46, ota::state == ota::Available || ota::state == ota::Writing ? "Update espOS tersedia >" : b, COL_MUTED);
  drawStatusIcons(oy + 12);

  // slider kecerahan
  rrect(12, oy + 58, 216, 34, 12, H(0xFFFFFF), 14);
  rrect(12.5f, oy + 58.5f, 215, 33, 11.5f, H(0xFFFFFF), 24, 1.0f);
  float sx0 = 30, sy0 = oy + 75;
  disc(sx0, sy0, 3.6f, COL_LABEL);
  for (int k = 0; k < 8; k++) { float an = k * 0.7853982f; disc(sx0 + cosf(an) * 8.0f, sy0 + sinf(an) * 8.0f, 1.1f, COL_LABEL); }
  float fr = (brightPct - 10) / 90.0f;
  rrect(46, oy + 72, 160, 6, 3, H(0xFFFFFF), 30);
  rrect(46, oy + 72, 160 * fr + 3, 6, 3, t.accent);
  disc(46 + 160 * fr, sy0, 10, H(0xF5F7FA));
  disc(46 + 160 * fr, sy0, 4, t.accent);

  static const int TX[3] = {12, 86, 160};
  int TY[2] = {oy + 100, oy + 170};

  if (cpMode == 0) {
    static char wsubBuf[34];
    const char* wsub;
    if (wifiSt == WF_ON) { fitText(F8, wifiSsid, 60, wsubBuf, sizeof(wsubBuf)); wsub = wsubBuf[0] ? wsubBuf : "Terhubung"; }
    else wsub = (wifiSt == WF_CONNECTING) ? "Menyambung" : (wifiSt == WF_FAIL) ? (wifiSsid[0] ? "Gagal" : "Belum diatur") : "Mati";
    const char* lb[6] = {"Wi-Fi", "Senter", "Kunci", "Tidur", "Deep Sleep", "Setelan"};
    const char* sb[6] = {wsub, flashOn ? FL_NAME[flashIdx] : "Mati", "", "", "", ""};
    for (int i = 0; i < 6; i++) {
      bool on = (i == 0 && wifiSt == WF_ON) || (i == 1 && flashOn);
      u16 oc = (i == 1) ? flashCol565(flashIdx) : t.accent;
      u16 ink = H(0x07201C);
      if (i == 1 && (flashIdx == 1 || flashIdx == 6 || flashIdx == 7)) ink = COL_WHITE;
      drawTile(i, TX[i % 3], TY[i / 3], on, cpSx[i], (cpPress == i) ? cpHold : 0.0f, lb[i], sb[i], oc, ink);
    }
    if ((cpPress == 0 || cpPress == 1) && cpHold > 0.15f)       // petunjuk saat tile ditahan
      drawText(F8, 120, oy + 243, cpPress == 0 ? "Tahan untuk pengaturan Wi-Fi" : "Tahan untuk pilih warna senter", t.accent, 255, 1);
  } else if (cpMode == 1) {                              // pilih warna senter
    rrect(12, oy + 100, 216, 134, 16, H(0x151C28));
    rrect(12.5f, oy + 100.5f, 215, 133, 15.5f, H(0xFFFFFF), 22, 1.0f);
    drawText(B13, 24, oy + 124, "Warna senter", COL_TEXT);
    drawText(F9, 190, oy + 123, FL_NAME[flashIdx], COL_MUTED, 255, 2);
    for (int k = 0; k < 8; k++) {
      int cx = 39 + (k % 4) * 54, cy = oy + 160 + (k / 4) * 50;
      disc(cx, cy, 17, flashCol565(k));
      if (flashOn && k == flashIdx) ringS(cx, cy, 21.5f, 2.0f, t.accent);
    }
  } else {                                               // konfirmasi deep sleep
    rrect(12, oy + 100, 216, 134, 16, H(0x151C28));
    rrect(12.5f, oy + 100.5f, 215, 133, 15.5f, H(0xFFFFFF), 22, 1.0f);
    drawText(B13, 120, oy + 128, "Masuk deep sleep?", COL_TEXT, 255, 1);
    drawText(F9, 120, oy + 150, "Layar & Wi-Fi mati total.", COL_MUTED, 255, 1);
    drawText(F9, 120, oy + 166, "Bangunkan dengan tombol BOOT.", COL_MUTED, 255, 1);
    rrect(24, oy + 184, 90, 34, 12, H(0x303946));
    drawText(B13, 69, oy + 205, "Batal", COL_WHITE, 255, 1);
    rrect(126, oy + 184, 90, 34, 12, t.accent);
    drawText(B13, 171, oy + 205, "Ya", H(0x07201C), 255, 1);
  }
  bool will = cpDrag && cpAnim > (cpOpen ? 0.6f : 0.35f);       // pegangan melebar + beraksen = "lepas sekarang akan membuka"
  rrect(will ? 105.0f : 110.0f, oy + CP_H - 12, will ? 30.0f : 20.0f, 3, 1.5f, will ? t.accent : H(0x39445A));
}

// ============================== KUNCI LAYAR: TAMPILAN PIN & POLA =============
static const int PIN_X0 = 16, PIN_KW = 64, PIN_KGX = 8, PIN_Y0 = 134, PIN_KH = 32, PIN_KGY = 5;
static const int PAT_CX[3] = {60, 120, 180}, PAT_CY[3] = {136, 194, 252}, PAT_HIT = 26;

static int pinKeyAt(int x, int y) {
  for (int k = 0; k < 12; k++) {
    int kx = PIN_X0 + (k % 3) * (PIN_KW + PIN_KGX), ky = PIN_Y0 + (k / 3) * (PIN_KH + PIN_KGY);
    if (x >= kx && x < kx + PIN_KW && y >= ky && y < ky + PIN_KH) return k;
  }
  return -1;
}
static int patDotAt(int x, int y) {
  for (int n = 0; n < 9; n++) {
    int dx = x - PAT_CX[n % 3], dy = y - PAT_CY[n / 3];
    if (dx * dx + dy * dy <= PAT_HIT * PAT_HIT) return n;
  }
  return -1;
}
static void thickLine(float x0, float y0, float x1, float y1, float r, u16 c) {
  float dx = x1 - x0, dy = y1 - y0, len = sqrtf(dx * dx + dy * dy);
  int n = (int)len + 1;
  for (int i = 0; i <= n; i++) { float f = (float)i / n; disc(x0 + dx * f, y0 + dy * f, r, c); }
}

// al = transparansi seluruh elemen, yo = geser vertikal (untuk animasi masuk)
static void drawCredUI(uint8_t al, int yo) {
  const Theme& t = THEMES[curTheme];
  int kind = credKind();
  uint32_t now = millis();
  const char* ttl;
  if (kind == 1) ttl = credPurpose < 2 ? "Masukkan PIN" : (credPurpose == 2 ? "Buat PIN baru" : "Ulangi PIN");
  else           ttl = credPurpose < 2 ? "Gambar pola" : (credPurpose == 2 ? "Buat pola baru" : "Ulangi pola");
  drawText(B13, 120, 80 + yo, ttl, COL_TEXT, al, 1);
  const char* msg = credMsg; u16 mc = credMsgErr ? H(0xFF7A7A) : t.accent;
  if (!msg[0]) {
    mc = COL_MUTED;
    if (credPurpose == 2) msg = kind == 1 ? "4 sampai 8 angka" : "Hubungkan minimal 4 titik";
    else if (credPurpose == 3) msg = "Ulangi untuk konfirmasi";
  }
  drawText(F9, 120, 100 + yo, msg, mc, al, 1);

  if (kind == 1) {
    int slots = credLen > 4 ? credLen : 4;
    float shake = 0;
    if (credShakeT && now - credShakeT < 450) { float k = (now - credShakeT) / 450.0f; shake = 9.0f * sinf(k * 28.0f) * (1.0f - k); }
    float x0 = 120.0f - (slots - 1) * 10.0f + shake, y = 118.0f + yo;
    for (int i = 0; i < slots; i++) {
      float cx = x0 + i * 20.0f;
      if (i < credLen) {
        float r = 5.2f;
        if (i == credLen - 1 && credPopT && now - credPopT < 160) r = 2.0f + 3.2f * easeOut((now - credPopT) / 160.0f);
        disc(cx, y, r, credMsgErr && now - credMsgT < 600 ? H(0xFF7A7A) : t.accent, al);
      } else disc(cx, y, 3.0f, COL_MUTED2, (uint8_t)(al * 140 / 255));
    }
    for (int k = 0; k < 12; k++) {
      float x = PIN_X0 + (k % 3) * (PIN_KW + PIN_KGX), yk = PIN_Y0 + (k / 3) * (PIN_KH + PIN_KGY) + yo;
      float pv = credSp[k], pc = clamp01(pv);
      u16 fill = (k == 11) ? t.accent : (k == 9 ? H(0x303946) : H(0x1B222C));
      if (pc > 0.01f) fill = mix(H(0xFFFFFF), fill, (uint8_t)(60.0f * pc));
      float in = 1.6f * pv;
      rrect(x + in, yk + in, PIN_KW - 2 * in, PIN_KH - 2 * in, 12, fill, al);
      if (k == 9) drawIcon(IC_BKSP, x + PIN_KW / 2, yk + PIN_KH / 2, COL_WHITE, al);
      else if (k == 11) drawText(B13, (int)x + PIN_KW / 2, (int)yk + 21, "OK", H(0x07201C), al, 1);
      else { char d[2] = { (char)(k == 10 ? '0' : '1' + k), 0 }; drawText(B13, (int)x + PIN_KW / 2, (int)yk + 21, d, COL_WHITE, al, 1); }
    }
  } else {
    u16 col = patErr ? H(0xFF6B6B) : t.accent;
    for (int i = 0; i + 1 < patLen; i++)
      thickLine(PAT_CX[patSeq[i] % 3], PAT_CY[patSeq[i] / 3] + yo, PAT_CX[patSeq[i + 1] % 3], PAT_CY[patSeq[i + 1] / 3] + yo, 1.9f, col);
    if (patDrag && patLen > 0 && !patErr)
      thickLine(PAT_CX[patSeq[patLen - 1] % 3], PAT_CY[patSeq[patLen - 1] / 3] + yo, patFx, patFy + yo, 1.9f, col);
    for (int n = 0; n < 9; n++) {
      float cx = PAT_CX[n % 3], cy = PAT_CY[n / 3] + yo;
      bool vis = false; for (int i = 0; i < patLen; i++) if (patSeq[i] == n) vis = true;
      if (vis) { disc(cx, cy, 8.0f, col, al); arcLine(cx, cy, 17.0f, 1.6f, 0, 359.9f, col, (uint8_t)(al * 130 / 255)); }
      else disc(cx, cy, 5.0f, COL_LABEL, (uint8_t)(al * 170 / 255));
    }
  }
  if (locked) drawText(F10, 120, 305, "Batal", COL_LABEL, al, 1);
}

// petunjuk saat tepi atas layar disentuh: cahaya lembut + pegangan yang memanjang
static void drawTopHint() {
  float h = clamp01(topHintX);
  if (h < 0.03f) return;
  const Theme& t = THEMES[curTheme];
  glow(120, -8, 96, t.accent, (uint8_t)(42.0f * h));
  rrect(120.0f - 12.0f - 10.0f * h, 3, 24.0f + 20.0f * h, 4, 2, t.accent, (uint8_t)(120.0f + 120.0f * h));
}

static void drawLock() {
  int sh = lockShift;
  copyBG();
  if (sh > 0 && lockSnapOK && snapBuf2 && lkType == 0) {   // tanpa kunci: layar di baliknya muncul perlahan saat digeser
    uint8_t ha = (uint8_t)(sh >= 170 ? 255 : sh * 255 / 170);
    for (int i = 0; i < SCR_W * SCR_H; i++) fb[i] = mix(snapBuf2[i], fb[i], ha);
  }
  drawStatusBar();
  drawTopHint();
  if (lockAuth) {                                        // minta PIN / pola (isi layar tidak pernah terlihat)
    float e = easeOut(clamp01((millis() - lockAuthT) / 240.0f));
    drawCredUI((uint8_t)(255.0f * e), (int)(18.0f * (1.0f - e)));
    return;
  }
  uint8_t al = (sh >= 140) ? 0 : (uint8_t)(255 - sh * 255 / 140);
  char b[44];
  drawText(F9, 120, 96 - sh, "Terkunci", COL_MUTED, al, 1);
  snprintf(b, sizeof(b), "%02d:%02d", clk_hh, clk_mm);
  drawText(CLK, 120, 150 - sh, b, COL_WHITE, al, 1);
  snprintf(b, sizeof(b), "%s, %d %s %d", HARI[clk_wd], clk_dd, BULAN[clk_mo], clk_yy);
  drawText(B13, 120, 180 - sh, b, COL_LABEL, al, 1);
  int bob = (sh == 0 && !lockDrag && !lockSpring) ? (int)(2.5f * sinf(millis() * 0.005f)) : 0;
  drawText(F9, 120, 284 - sh / 2 + bob, lkType ? "Geser ke atas untuk membuka kunci" : "Geser ke atas untuk membuka", COL_MUTED, al, 1);
  float pw = 60.0f + (lockDrag ? (sh > 100 ? 100 : sh) * 0.5f : 0.0f);
  rrect(120.0f - pw / 2, 298 - sh / 2 + bob, pw, 4, 2, COL_LABEL, al);
}

static const char* titleFor(Screen s) {
  switch (s) {
    case SC_NOTES: return "Catatan"; case SC_FILES: return "Berkas";
    case SC_STOPWATCH: return "Stopwatch"; case SC_SYSINFO: return "Info sistem"; case SC_SETTINGS: return "Setelan";
    case SC_SETTIME: return "Atur jam & tanggal"; case SC_OTA: return "Update espOS"; case SC_ABOUT: return "Tentang";
    case SC_LOCKSET: return "Kunci layar"; case SC_PINPAD: return "PIN"; case SC_PATTERN: return "Pola";
    case SC_RECENTS: return "Aplikasi terbaru"; case SC_WIFI: return "Wi-Fi"; default: return "";
  }
}

// ============================== LAYAR WI-FI & PASSWORD =======================
static bool wfIsCur(const char* ssid)  { return wifiSt == WF_ON && wifiSsid[0] && !strcmp(ssid, wifiSsid); }
static bool wfIsConn(const char* ssid) { return wifiSt == WF_CONNECTING && !strcmp(ssid, pendSave ? pendSsid : wifiSsid); }
static int  wfBars(int rssi) { return rssi >= -55 ? 4 : (rssi >= -65 ? 3 : (rssi >= -75 ? 2 : 1)); }

static void drawSignal(int x, int yb, int lv, u16 c) {
  for (int i = 0; i < 4; i++) { int hh = 4 + i * 3; rrect(x + i * 5, yb - hh, 3.4f, hh, 1.2f, c, i < lv ? 255 : 55); }
}
static void drawLockMini(float cx, float cy, u16 c) {
  ringS(cx, cy - 3, 3.6f, 1.6f, c);
  rrect(cx - 5, cy - 1, 10, 8, 2, c);
}

static void drawWifiScreen() {
  const Theme& t = THEMES[curTheme];
  bool on = wifiWant;
  rrect(186, 40, 42, 22, 11, on ? t.accent : H(0x39445A));            // saklar
  disc(on ? 217.0f : 197.0f, 51, 8.5f, COL_WHITE);

  int pages = (wfCount + 4) / 5; if (pages < 1) pages = 1;
  if (wfPage >= pages) wfPage = pages - 1;

  if (wfToast[0] && millis() < wfToastUntil) drawText(F8, 16, 77, wfToast, t.accent);
  else drawText(F8, 16, 77, on ? "Jaringan tersedia" : "Wi-Fi mati", COL_MUTED);
  if (on && wfScanRunning) disc(124, 74.5f, 2.2f, t.accent);          // titik = sedang memindai
  if (pages > 1) {
    char pg[12]; snprintf(pg, sizeof(pg), "%d/%d", wfPage + 1, pages);
    drawText(F8, 184, 77, pg, COL_MUTED, 255, 1);
    bool pv = wfPage > 0, nx = (wfPage + 1) < pages;
    drawIcon(IC_CHEV_L, 150, 74, pv ? COL_LABEL : COL_MUTED2, pv ? 255 : 80);
    drawIcon(IC_CHEV_R, 218, 74, nx ? COL_LABEL : COL_MUTED2, nx ? 255 : 80);
  }

  if (!on) {
    drawText(B13, 120, 150, "Wi-Fi mati", COL_LABEL, 255, 1);
    drawText(F8, 120, 168, "Nyalakan saklar untuk mencari jaringan", COL_MUTED, 255, 1);
    return;
  }
  if (wfCount == 0) {
    drawText(B13, 120, 150, "Memindai jaringan...", COL_LABEL, 255, 1);
    drawText(F8, 120, 168, "Dipindai ulang otomatis tiap 2 detik", COL_MUTED, 255, 1);
    return;
  }
  for (int i = 0; i < 5; i++) {
    int idx = wfPage * 5 + i; if (idx >= wfCount) break;
    const WfNet& n = wfNet[idx];
    int y = 84 + i * 40;
    float pv = clamp01(bpX[3 + i]);                       // tombol baris jaringan = indeks 3..7
    bool cur = wfIsCur(n.ssid), cing = wfIsConn(n.ssid);
    rrect(12, y, 216, 36, 12, H(0xFFFFFF), (uint8_t)((cur ? 22.0f : 14.0f) + 20.0f * pv));
    drawRipple(3 + i, 12, y, 216, 36, 12);
    rrect(12.5f, y + 0.5f, 215, 35, 11.5f, cur ? t.accent : H(0xFFFFFF), cur ? 120 : 24, 1.0f);
    drawSignal(24, y + 25, wfBars(n.rssi), cur ? t.accent : COL_TEXT);
    char nm[34]; fitText(F10, n.ssid, 140, nm, sizeof(nm));
    drawText(F10, 52, y + 16, nm, COL_TEXT);
    const char* sub = cur ? "Terhubung" : (cing ? "Menyambung..." : (n.secure ? "Dilindungi" : "Terbuka"));
    drawText(F8, 52, y + 29, sub, (cur || cing) ? t.accent : COL_MUTED);
    if (n.secure) drawLockMini(214, y + 18, COL_MUTED2);
  }
}

static void drawPassScreen() {
  const Theme& t = THEMES[curTheme];
  char nm[34]; fitText(B13, selSsid, 208, nm, sizeof(nm));
  drawText(B13, 16, 56, nm, COL_TEXT);
  if (pwMsg[0] && millis() < pwMsgUntil) drawText(F8, 16, 70, pwMsg, pwMsgErr ? H(0xFF7A7A) : t.accent);
  else if (pwBusy()) drawText(F8, 16, 70, "Menyambung...", t.accent);
  else drawText(F8, 16, 70, selSecure ? "Masukkan password (minimal 8 karakter)" : "Jaringan terbuka", COL_MUTED);

  // kolom password
  rrect(12, 78, 216, 30, 12, H(0xFFFFFF), 14);
  rrect(12.5f, 78.5f, 215, 29, 11.5f, t.accent, 170, 1.2f);
  float cx = 22;
  if (pwLen == 0) drawText(F10, 22, 98, "Password", COL_MUTED2);
  else if (pwShow) {
    int st = 0; while (st < pwLen && textWidth(F10, pwBuf + st) > 150) st++;
    drawText(F10, 22, 98, pwBuf + st, COL_TEXT);
    cx = 22 + textWidth(F10, pwBuf + st) + 1;
  } else {
    int vis = pwLen > 15 ? 15 : pwLen, st = pwLen - vis;
    for (int k = 0; k < vis; k++) {
      int dx = 27 + k * 10;
      if (st + k == pwLen - 1 && millis() - pwLastMs < 700) { char c[2] = {pwBuf[st + k], 0}; drawText(F10, dx, 98, c, COL_TEXT, 255, 1); }   // huruf terakhir sempat terlihat
      else disc(dx, 93, 3.0f, COL_TEXT);
    }
    cx = 22 + vis * 10 + 1;
  }
  if (!pwBusy() && ((millis() / 500) & 1) == 0) rrect(cx, 83, 1.6f, 20, 0.8f, t.accent);
  drawText(F9, 222, 97, pwShow ? "Sembunyi" : "Lihat", t.accent, 255, 2);

  // tombol Sambung
  bool ok = (!selSecure) || pwLen >= 8, busy = pwBusy();
  float pv = clamp01(bpX[1]);                            // tombol Sambung = indeks 1
  u16 f = (ok || busy) ? t.accent : H(0x303946);
  if (pv > 0.01f) f = mix(H(0xFFFFFF), f, (uint8_t)(55.0f * pv));
  rrect(12, 114, 216, 26, 13, f);
  drawRipple(1, 12, 114, 216, 26, 13);
  drawText(B13, 120, 132, busy ? "Menyambung..." : "Sambung", (ok || busy) ? H(0x07201C) : COL_MUTED, 255, 1);
}

// gelembung huruf di atas tombol keyboard yang sedang ditekan (seperti keyboard HP)
static void drawKeyPopup() {
  if (pressedId < 0 || pressedId >= nbtn) return;
  const Btn& b = btns[pressedId];
  if (b.style != B_KB || !b.label[0]) return;
  float w = b.w + 14, hh = 40;
  float x = b.x + b.w * 0.5f - w * 0.5f; if (x < 2) x = 2; if (x + w > SCR_W - 2) x = SCR_W - 2 - w;
  float y = b.y - hh - 2;
  rrect(x + 1, y + 3, w, hh, 10, 0x0000, 90);
  rrect(x, y, w, hh, 10, H(0x4B586C));
  rrect(x + 0.5f, y + 0.5f, w - 1, hh - 1, 9.5f, H(0xFFFFFF), 40, 1.0f);
  drawText(B13, (int)(x + w * 0.5f), (int)(y + hh * 0.5f) + 5, b.label, COL_WHITE, 255, 1);
}

static void drawExtras() {
  const Theme& t = THEMES[curTheme];
  char b1[48], b2[24];
  switch (screen) {
    case SC_DINO: case SC_PONG: case SC_FLAPPY: gameDraw(); break;
    case SC_CALC: {
      drawText(F9, 224, 84, calcExpr, COL_MUTED, 255, 2);
      const AFont& f = textWidth(N30, calcDisp) <= 204 ? N30 : B13;
      drawText(f, 224, (&f == &N30) ? 118 : 114, calcDisp, COL_WHITE, 255, 2);
      break;
    }
    case SC_NOTES:
      drawText(F8, 120, 281, fsOK ? "Catatan tersimpan di memori flash" : "Flash tidak tersedia - catatan tidak tersimpan", COL_MUTED2, 255, 1);
      break;
    case SC_NOTEEDIT: {
      snprintf(b1, sizeof(b1), "Catatan %d", noteSlot + 1);
      drawText(B13, 16, 56, b1, COL_TEXT);
      snprintf(b1, sizeof(b1), "%d/180", noteLen);
      drawText(F8, 166, 54, b1, COL_MUTED, 255, 2);
      rrect(12, 66, 216, 92, 12, H(0xFFFFFF), 14);
      rrect(12.5f, 66.5f, 215, 91, 11.5f, H(0xFFFFFF), 24, 1.0f);
      static char tmp[192];
      snprintf(tmp, sizeof(tmp), "%s%c", noteText, ((millis() / 500) & 1) ? '|' : ' ');
      const char* st[40]; int ln[40];
      int n = wrapLines(F10, 200, tmp, st, ln, 40);
      int first = n > 6 ? n - 6 : 0;
      drawLines(F10, 20, 83, 14, st, ln, first, n, COL_TEXT);
      break;
    }
    case SC_FILES: {
      fmtSize(fsOK ? LittleFS.usedBytes() : 0, b1); fmtSize(fsOK ? LittleFS.totalBytes() : 0, b2);
      char inf[44]; snprintf(inf, sizeof(inf), "%s / %s", b1, b2);
      drawText(F9, 14, 80, "Penyimpanan", COL_MUTED);
      drawText(F9, 226, 80, inf, COL_LABEL, 255, 2);
      rrect(14, 87, 212, 5, 2.5f, H(0xFFFFFF), 30);
      float fr = (fsOK && LittleFS.totalBytes()) ? (float)LittleFS.usedBytes() / LittleFS.totalBytes() : 0;
      if (fr > 0.01f) rrect(14, 87, 212 * fr, 5, 2.5f, t.accent);
      int pages = (fCount + 3) / 4; if (pages < 1) pages = 1;
      snprintf(b1, sizeof(b1), "Hal %d/%d", fPage + 1, pages);
      drawText(F8, 226, 102, b1, COL_MUTED, 255, 2);
      drawText(B13, 16, 56, "Berkas", COL_TEXT);
      if (!fsOK) drawText(F9, 120, 170, "Flash (LittleFS) tidak tersedia", COL_MUTED, 255, 1);
      else if (fCount == 0) {
        drawText(F9, 120, 168, "Belum ada berkas", COL_LABEL, 255, 1);
        drawText(F8, 120, 186, "Buat catatan di aplikasi Catatan", COL_MUTED, 255, 1);
      }
      break;
    }
    case SC_FILEVIEW: {
      drawText(B13, 16, 56, viewName, COL_TEXT);
      fmtSize(viewLen, b2); snprintf(b1, sizeof(b1), "Ukuran tampil: %s", b2);
      drawText(F8, 16, 71, b1, COL_MUTED);
      rrect(12, 78, 216, 162, 12, H(0xFFFFFF), 14);
      rrect(12.5f, 78.5f, 215, 161, 11.5f, H(0xFFFFFF), 24, 1.0f);
      if (viewBinary) drawText(F9, 120, 160, "Berkas biner - tidak dapat ditampilkan", COL_MUTED, 255, 1);
      else if (viewLen == 0) drawText(F9, 120, 160, "(kosong)", COL_MUTED, 255, 1);
      else {
        const char* st[40]; int ln[40];
        int n = wrapLines(F9, 200, viewBuf, st, ln, 40);
        drawLines(F9, 20, 96, 14, st, ln, 0, n > 11 ? 11 : n, COL_TEXT);
      }
      break;
    }
    case SC_STOPWATCH: {
      uint32_t ms = swElapsed();
      snprintf(b1, sizeof(b1), "%02u:%02u.%02u", (unsigned)(ms / 60000) % 100, (unsigned)(ms / 1000) % 60, (unsigned)(ms / 10) % 100);
      rrect(12, 90, 216, 90, 16, H(0xFFFFFF), 12);
      rrect(12.5f, 90.5f, 215, 89, 15.5f, H(0xFFFFFF), 22, 1.0f);
      drawText(N30, 120, 148, b1, swRunning ? t.accent : COL_WHITE, 255, 1);
      drawText(F9, 120, 202, swRunning ? "Berjalan" : (ms ? "Berhenti" : "Siap"), COL_MUTED, 255, 1);
      break;
    }
         case SC_SYSINFO: {
      static char l1[8][2][28];
      char a[16], c[16];
      uint32_t intFree = ESP.getFreeHeap(),  intTot = ESP.getHeapSize();
      uint32_t psFree  = psramFound() ? ESP.getFreePsram() : 0;
      uint32_t psTot   = psramFound() ? ESP.getPsramSize() : 0;

      snprintf(l1[0][0], 28, "Chip");         snprintf(l1[0][1], 28, "%s", ESP.getChipModel());
      snprintf(l1[1][0], 28, "CPU");          snprintf(l1[1][1], 28, "%u MHz", (unsigned)ESP.getCpuFreqMHz());
      fmtSize(intFree + psFree, a);
      snprintf(l1[2][0], 28, "RAM bebas");    snprintf(l1[2][1], 28, "%s", a);
      fmtSize(intTot + psTot, a);
      snprintf(l1[3][0], 28, "RAM total");    snprintf(l1[3][1], 28, "%s", a);
      fmtSize(intFree, a); fmtSize(intTot, c);
      snprintf(l1[4][0], 28, "RAM internal"); snprintf(l1[4][1], 28, "%s / %s", a, c);
      if (psTot) { fmtSize(psFree, a); fmtSize(psTot, c); snprintf(l1[5][1], 28, "%s / %s", a, c); }
      else snprintf(l1[5][1], 28, "tidak aktif");
      snprintf(l1[5][0], 28, "PSRAM");
      snprintf(l1[6][0], 28, "Flash");        snprintf(l1[6][1], 28, "%u MB", (unsigned)(ESP.getFlashChipSize() / 1048576));
      uint32_t s = millis() / 1000;
      snprintf(l1[7][0], 28, "Waktu aktif");  snprintf(l1[7][1], 28, "%u:%02u:%02u", (unsigned)(s / 3600), (unsigned)(s / 60) % 60, (unsigned)s % 60);

      drawText(B13, 16, 56, "Info sistem", COL_TEXT);
      rrect(12, 66, 216, 216, 14, H(0xFFFFFF), 12);
      rrect(12.5f, 66.5f, 215, 215, 13.5f, H(0xFFFFFF), 22, 1.0f);
      for (int i = 0; i < 8; i++) {
        drawText(F9, 24, 88 + i * 26, l1[i][0], COL_MUTED);
        drawText(F9, 216, 88 + i * 26, l1[i][1], COL_TEXT, 255, 2);
        if (i < 7) rrect(22, 96 + i * 26, 196, 1, 0.5f, H(0xFFFFFF), 20);
      }
      break;
    }
    case SC_SETTIME: {
      static const char* LBL[5] = {"Jam", "Menit", "Hari", "Tanggal", "Bulan"};
      for (int f = 0; f < 5; f++) {
        int y = 70 + f * 42;
        rrect(12, y - 2, 216, 36, 12, H(0xFFFFFF), 10);
        drawText(F9, 22, y + 21, LBL[f], COL_MUTED);
        const char* v;
        switch (f) {
          case 0: snprintf(b2, sizeof(b2), "%02d", clk_hh); v = b2; break;
          case 1: snprintf(b2, sizeof(b2), "%02d", clk_mm); v = b2; break;
          case 2: v = HARI[clk_wd]; break;
          case 3: snprintf(b2, sizeof(b2), "%d", clk_dd); v = b2; break;
          default: v = BULAN[clk_mo]; break;
        }
        drawText(B9, 124, y + 21, v, COL_TEXT, 255, 2);
      }
      break;
    }
    case SC_ABOUT: {
      int tw = textWidth(B29, "espOS"), x = 120 - tw / 2;
      int w1 = drawText(B29, x, 120, "esp", COL_WHITE);
      drawText(B29, x + w1, 120, "OS", t.accent);
      drawText(F9, 120, 146, "Versi 1.6", COL_LABEL, 255, 1);
      drawText(F9, 120, 176, "Mini HP untuk ESP32-S3", COL_MUTED, 255, 1);
      drawText(F9, 120, 194, "Layar TFT ILI9341 2.8\"", COL_MUTED, 255, 1);
      drawText(F9, 120, 230, "Dibuat oleh Farel", COL_LABEL, 255, 1);
      break;
    }
    case SC_LOCKSET: {
      int ay = lkType == 0 ? 70 : (lkType == 1 ? 120 : 170);
      drawIcon(IC_CHECK, 196, ay + 22, t.accent);
      drawText(F8, 120, 236, "PIN 4-8 angka atau pola min. 4 titik", COL_MUTED, 255, 1);
      drawText(F8, 120, 250, "diminta setiap membuka kunci layar", COL_MUTED, 255, 1);
      break;
    }
    case SC_PINPAD: case SC_PATTERN: drawCredUI(255, 0); break;
    case SC_WIFI:     drawWifiScreen(); break;
    case SC_WIFIPASS: drawPassScreen();  break;
    case SC_RECENTS:
      if (recents[0] < 0) drawText(F9, 120, 160, "Tidak ada aplikasi terbaru", COL_MUTED, 255, 1);
      break;
    default: break;
  }
}

static void drawScene() {
  if (locked) { drawLock(); drawControlPanel(); return; }
  copyBG();
  drawStatusBar();
  drawTopHint();
  if (screen == SC_HOME) drawHomeTop();
  else if (screen != SC_CALC && screen != SC_NOTEEDIT && screen != SC_FILES && screen != SC_FILEVIEW && screen != SC_SYSINFO) {
    const char* tt = titleFor(screen); if (tt[0]) drawText(B13, 16, 56, tt, COL_TEXT);
  }
  if (screen == SC_WIFIPASS) rrect(0, 142, SCR_W, SCR_H - 142, 0, H(0x0A0F16), 235);   // alas keyboard
  if (screen == SC_HOME) drawHomePages();
  else for (int i = 0; i < nbtn; i++) drawBtn(btns[i], i == pressedId, bpX[i], i);
  drawExtras();
  drawKeyPopup();
  drawNav(COL_LABEL, 70);
  drawSheet();
  drawControlPanel();
}
static void renderFrame() { drawScene(); pushFrame(); }

// ============================== BOOT =========================================
static void drawLogo(float p) {
  float a = easeOut(p * 2.4f);
  uint8_t al = (uint8_t)(255 * a);
  float hS = 46.0f * easeOut(p * 1.7f);
  float wT = 40.0f * easeOut(p * 1.6f - 0.15f);
  float wM = 22.0f * easeOut(p * 1.6f - 0.30f);
  float wB = 45.0f * easeOut(p * 1.6f - 0.45f);
  float sq = easeOut(p * 3.0f - 1.9f);
  if (wB > 1) rrect(96, 132, wB, 10, 3.5f, H(0x8F8CF6), al);
  if (hS > 1) rrect(96, 96, 11.5f, hS, 3.5f, H(0x6CF0D2), al);
  if (wT > 1) rrect(96, 96, wT, 10, 3.5f, H(0x6CF0D2), al);
  if (wM > 1) rrect(108, 114, wM, 10, 3.5f, H(0xBDF8EA), al);
  if (sq > 0.02f) { float s = 11.0f * sq; rrect(137.5f + (11 - s) / 2, 96 + (11 - s) / 2, s, s, 3.2f, H(0x8F8CF6), (uint8_t)(255 * sq)); }
}

static void renderBoot(uint32_t t) {
  fillSolid(BOOT_BG);
  glow(120, 118, 125, H(0x0B343C), 60);
  float pl = t / 1000.0f;
  static const int8_t SPX[6][2] = {{-62,-30},{-30,-62},{22,-54},{36,-4},{-48,28},{4,34}};
  float sf = 1.0f - smooth((t - 350) / 1100.0f);
  if (sf > 0) for (int i = 0; i < 6; i++) {
    float tw = 0.5f + 0.5f * sinf(t * 0.012f + i * 1.7f);
    disc(120 + SPX[i][0], 119 + SPX[i][1], 1.5f, H(0x7FF5DC), (uint8_t)(200 * sf * tw));
  }
  drawLogo(pl > 1 ? 1 : pl);
  float ta = smooth((t - 700) / 450.0f);
  if (ta > 0) {
    int tw = textWidth(B29, "espOS"), x = 120 - tw / 2;
    int yy = 190 - (int)((1 - ta) * 5);
    int w1 = drawText(B29, x, yy, "esp", COL_WHITE, (uint8_t)(255 * ta));
    drawText(B29, x + w1, yy, "OS", H(0x6CF0D2), (uint8_t)(255 * ta));
  }
  float fa = smooth((t - 1300) / 400.0f);
  if (fa > 0) {
    float prog = smooth((t - 1500) / 3000.0f);
    rrect(66, 247, 108, 3, 1.5f, H(0x121C27), (uint8_t)(255 * fa));
    if (prog > 0.01f) rrect(66, 247, 108 * prog, 3, 1.5f, prog >= 1.0f ? H(0x3FAE93) : H(0x6CF0D2), (uint8_t)(255 * fa));
    drawText(F8, 120, 269, prog >= 1.0f ? "Siap." : "Menyiapkan espOS", COL_MUTED, (uint8_t)(255 * fa), 1);
    drawText(F7, 120, 305, "DIBUAT OLEH FAREL", H(0x5D6676), (uint8_t)(255 * fa), 1);
  }
}

static void bootSequence() {
  const uint32_t BOOT_MS = 5000;
  uint32_t t0 = millis();
  bool first = true;
  for (;;) {
    uint32_t t = millis() - t0; if (t > BOOT_MS) t = BOOT_MS;
    renderBoot(t); pushFrame();
    if (first) { fadeBacklight(0, blLevel, 350); first = false; }
    if (t >= BOOT_MS) break;
  }
  if (snapBuf) memcpy(snapBuf, fb, FB_BYTES);
  uint32_t f0 = millis();
  for (;;) {
    uint32_t dt = millis() - f0; if (dt > 520) break;
    float a = smooth(dt / 520.0f);
    drawScene();
    if (snapBuf) { uint8_t al = (uint8_t)(255 * a); for (int i = 0; i < SCR_W * SCR_H; i++) fb[i] = mix(fb[i], snapBuf[i], al); }
    else { uint8_t da = (uint8_t)(255 * (1 - a)); for (int i = 0; i < SCR_W * SCR_H; i++) fb[i] = mix(0x0000, fb[i], da); }
    pushFrame();
  }
}

// ============================== TOUCH XPT2046 ================================
static int calX0 = TOUCH_X_MIN, calX1 = TOUCH_X_MAX, calY0 = TOUCH_Y_MIN, calY1 = TOUCH_Y_MAX, calSwap = TOUCH_SWAP_XY;
static bool calOK = false;

static uint16_t tsXfer(uint8_t cmd) {
  tftSPI.beginTransaction(SPISettings(1000000, MSBFIRST, SPI_MODE0));
  digitalWrite(PIN_TS_CS, LOW);
  tftSPI.transfer(cmd);
  uint16_t v = tftSPI.transfer16(0);
  digitalWrite(PIN_TS_CS, HIGH);
  tftSPI.endTransaction();
  return v >> 3;
}
static void sort5(int* a) { for (int i = 1; i < 5; i++) { int k = a[i], j = i - 1; while (j >= 0 && a[j] > k) { a[j + 1] = a[j]; j--; } a[j + 1] = k; } }

// nilai mentah (median 5 sampel). false = tidak disentuh / sinyal terlalu berisik
static bool tsRaw(int& rx, int& ry) {
  int z1 = tsXfer(0xB1), z2 = tsXfer(0xC1);
  if (z1 + 4095 - z2 < TOUCH_Z_MIN) return false;
  int xs[5], ys[5];
  tsXfer(0xD1);
  for (int i = 0; i < 5; i++) { xs[i] = tsXfer(0xD1); ys[i] = tsXfer(0x91); }
  tsXfer(0x90);
  sort5(xs); sort5(ys);
  if (xs[4] - xs[0] > 350 || ys[4] - ys[0] > 350) return false;
  rx = (xs[1] + xs[2] + xs[3]) / 3; ry = (ys[1] + ys[2] + ys[3]) / 3;
#if TOUCH_DEBUG
  Serial.printf("touch raw x=%d y=%d\n", rx, ry);
#endif
  return true;
}
static bool tsRead(int& sx, int& sy) {
  int rx, ry; if (!tsRaw(rx, ry)) return false;
  int ax = calSwap ? ry : rx, ay = calSwap ? rx : ry;
  long mx = (long)(ax - calX0) * (SCR_W - 1) / (calX1 - calX0);
  long my = (long)(ay - calY0) * (SCR_H - 1) / (calY1 - calY0);
  if (mx < 0) mx = 0; if (mx > SCR_W - 1) mx = SCR_W - 1;
  if (my < 0) my = 0; if (my > SCR_H - 1) my = SCR_H - 1;
  sx = (int)mx; sy = (int)my;
  return true;
}

// tunggu sentuhan, rata-ratakan, tunggu lepas
static void waitTouchRaw(int& rx, int& ry) {
  for (;;) {
    int a, b;
    if (tsRaw(a, b)) {
      long sx = 0, sy = 0; int n = 0; uint32_t t0 = millis();
      while (millis() - t0 < 450) { int c, d; if (tsRaw(c, d)) { sx += c; sy += d; n++; } delay(6); }
      if (n < 6) continue;
      rx = sx / n; ry = sy / n;
      int miss = 0; while (miss < 6) { int c, d; if (tsRaw(c, d)) miss = 0; else miss++; delay(10); }
      return;
    }
    delay(10);
  }
}
static void drawCross(int x, int y, u16 c) {
  rrect(x - 13, y - 0.75f, 26, 1.5f, 0.75f, c);
  rrect(x - 0.75f, y - 13, 1.5f, 26, 0.75f, c);
  ringS(x, y, 8, 1.5f, c);
}
static void calibrate() {
  static const int TX[4] = {20, 219, 20, 219};
  static const int TY[4] = {20, 20, 299, 299};
  int rx[4], ry[4];
  for (int i = 0; i < 4; i++) {
    fillSolid(BOOT_BG);
    drawText(B13, 120, 120, "Kalibrasi touch", COL_TEXT, 255, 1);
    drawText(F9, 120, 142, "Sentuh titik + dengan ujung jari", COL_MUTED, 255, 1);
    char b[16]; snprintf(b, sizeof(b), "%d / 4", i + 1);
    drawText(F9, 120, 164, b, THEMES[curTheme].accent, 255, 1);
    drawCross(TX[i], TY[i], THEMES[curTheme].accent);
    pushFrame();
    waitTouchRaw(rx[i], ry[i]);
  }
  // sumbu mana yang berubah ke arah horizontal layar?
  int dX = abs(rx[1] - rx[0]) + abs(rx[3] - rx[2]), dY = abs(ry[1] - ry[0]) + abs(ry[3] - ry[2]);
  int sw = dY > dX ? 1 : 0;
  int ax[4], ay[4];
  for (int i = 0; i < 4; i++) { ax[i] = sw ? ry[i] : rx[i]; ay[i] = sw ? rx[i] : ry[i]; }
  float axl = (ax[0] + ax[2]) / 2.0f, axr = (ax[1] + ax[3]) / 2.0f;     // sumbu X di layar x=20 dan x=219
  float ayt = (ay[0] + ay[1]) / 2.0f, ayb = (ay[2] + ay[3]) / 2.0f;     // sumbu Y di layar y=20 dan y=299
  float sx = (axr - axl) / 199.0f, sy = (ayb - ayt) / 279.0f;
  int nx0 = (int)(axl - sx * 20), nx1 = (int)(axl + sx * 219);
  int ny0 = (int)(ayt - sy * 20), ny1 = (int)(ayt + sy * 299);
  bool good = abs(nx1 - nx0) > 800 && abs(ny1 - ny0) > 800;
  fillSolid(BOOT_BG);
  if (good) {
    calX0 = nx0; calX1 = nx1; calY0 = ny0; calY1 = ny1; calSwap = sw; calOK = true;
    prefs.putInt("cx0", calX0); prefs.putInt("cx1", calX1); prefs.putInt("cy0", calY0); prefs.putInt("cy1", calY1);
    prefs.putUChar("csw", (uint8_t)calSwap); prefs.putUChar("cok", 1);
    drawText(B13, 120, 150, "Kalibrasi berhasil", THEMES[curTheme].accent, 255, 1);
  } else {
    drawText(B13, 120, 140, "Kalibrasi gagal", H(0xFF8A80), 255, 1);
    drawText(F9, 120, 162, "Ulangi dari Setelan > Kalibrasi", COL_MUTED, 255, 1);
  }
  pushFrame(); delay(900);
}

// ============================== AKSI =========================================
// ============================== LED SENTER, WI-FI, NTP, SLEEP ================
static void ledWrite(uint8_t r, uint8_t g, uint8_t b) { neopixelWrite(PIN_FLASH_LED, r, g, b); }
static void flashApply() {
  if (!flashOn) { ledWrite(0, 0, 0); return; }
  ledWrite((uint8_t)((FL_RGB[flashIdx][0] * FLASH_LEVEL) / 255),
           (uint8_t)((FL_RGB[flashIdx][1] * FLASH_LEVEL) / 255),
           (uint8_t)((FL_RGB[flashIdx][2] * FLASH_LEVEL) / 255));
}
static void flashToggle() {                              // ketuk: putih <-> mati
  if (flashOn) flashOn = false; else { flashOn = true; flashIdx = 0; }
  flashApply(); dirty = true;
}
static void flashPick(int idx) { flashIdx = (uint8_t)idx; flashOn = true; flashApply(); dirty = true; }

static void setToast(const char* m) { strncpy(wfToast, m, sizeof(wfToast) - 1); wfToast[sizeof(wfToast) - 1] = 0; wfToastUntil = millis() + 3000UL; dirty = true; }
static void setPwMsg(const char* m, bool err) { strncpy(pwMsg, m, sizeof(pwMsg) - 1); pwMsg[sizeof(pwMsg) - 1] = 0; pwMsgErr = err; pwMsgUntil = millis() + 4000UL; dirty = true; }
static void pwWipe() { memset(pwBuf, 0, sizeof(pwBuf)); pwLen = 0; pwShow = false; pwMsg[0] = 0; kbL = 0; }
static void wifiScanAbort() {
  if (wfScanRunning) { esp_wifi_scan_stop(); WiFi.scanDelete(); wfScanRunning = false; }
}

static void wifiStart() {
  dirty = true;
  WiFi.mode(WIFI_STA);                                   // radio hidup (juga dibutuhkan untuk memindai)
  if (!wifiSsid[0]) { wifiSt = WF_FAIL; wifiT0 = millis(); return; }
  WiFi.setAutoReconnect(true);
  WiFi.begin(wifiSsid, wifiPass);
  wifiSt = WF_CONNECTING; wifiT0 = millis();
}
static void wifiStop() {
  wfScanRunning = false; wfCount = 0; pendSave = false; memset(pendPass, 0, sizeof(pendPass));
  WiFi.disconnect(true);
  WiFi.mode(WIFI_OFF);
  wifiSt = WF_OFF; ntpPending = false; dirty = true;
}
static void wifiToggle() {
  wifiWant = !wifiWant;
  prefs.putUChar("wifi", wifiWant ? 1 : 0);
  if (wifiWant) { wfScanT0 = millis() - WIFI_SCAN_MS; wifiStart(); } else wifiStop();
}
// sambung ke jaringan pilihan pengguna; kredensial disimpan HANYA jika berhasil tersambung
static void wifiConnectTo(const char* ssid, const char* pass) {
  strncpy(pendSsid, ssid, 32); pendSsid[32] = 0;
  strncpy(pendPass, pass, 63); pendPass[63] = 0;
  pendSave = true;
  wifiScanAbort();
  wifiWant = true; prefs.putUChar("wifi", 1);
  WiFi.mode(WIFI_STA);
  WiFi.setAutoReconnect(false);                          // agar password salah terdeteksi cepat
  WiFi.disconnect(false);
  WiFi.begin(pendSsid, pendPass);
  wifiSt = WF_CONNECTING; wifiT0 = millis(); ntpPending = false; dirty = true;
}

// ambil waktu dari jam sistem (diisi NTP) -> jam espOS
static bool syncFromSystem() {
  struct tm ti;
  if (!getLocalTime(&ti, 0) || ti.tm_year < 120) return false;      // belum tersinkron
  clk_hh = ti.tm_hour; clk_mm = ti.tm_min; clk_wd = ti.tm_wday;
  clk_dd = ti.tm_mday; clk_mo = ti.tm_mon; clk_yy = ti.tm_year + 1900;
  lastMinuteMs = millis() - (uint32_t)ti.tm_sec * 1000UL;           // menit berganti tepat pada detik ke-0
  timeSynced = true; ntpLastMs = millis(); dirty = true;
  return true;
}

static void wifiTask(uint32_t now) {
  static uint32_t last = 0;
  if (now - last < 300) return;
  last = now;
  switch (wifiSt) {
    case WF_CONNECTING: {
      wl_status_t st = WiFi.status();
      if (st == WL_CONNECTED) {
        wifiSt = WF_ON; ntpPending = true; dirty = true;
        WiFi.setAutoReconnect(true);
        configTzTime(NTP_TZ, "pool.ntp.org", "time.google.com", "id.pool.ntp.org");
        Serial.printf("Wi-Fi terhubung, sinkron NTP (WIB). RAM bebas: %u KB\n", (unsigned)(ESP.getFreeHeap() / 1024));
        if (pendSave) {                                   // simpan jaringan + password ke flash
          strncpy(wifiSsid, pendSsid, 32); wifiSsid[32] = 0;
          strncpy(wifiPass, pendPass, 63); wifiPass[63] = 0;
          prefs.putString("wssid", wifiSsid); prefs.putString("wpass", wifiPass);
          pendSave = false; memset(pendPass, 0, sizeof(pendPass));
          setToast("Tersambung");
          if (screen == SC_WIFIPASS) { pwWipe(); goScreen(SC_WIFI); }
        }
      } else if (now - wifiT0 > (pendSave ? 15000UL : 20000UL) ||
                 (pendSave && now - wifiT0 > 4000UL && (st == WL_CONNECT_FAILED || st == WL_NO_SSID_AVAIL))) {
        wifiSt = WF_FAIL; wifiT0 = now; WiFi.disconnect(false); dirty = true;
        if (pendSave) {
          pendSave = false; memset(pendPass, 0, sizeof(pendPass));
          if (screen == SC_WIFIPASS) setPwMsg("Gagal tersambung. Cek password.", true);
          else setToast("Gagal tersambung");
        }
      }
      break;
    }
    case WF_ON:
      if (WiFi.status() != WL_CONNECTED) { wifiSt = WF_CONNECTING; wifiT0 = now; dirty = true; }
      else if (ntpPending) { if (syncFromSystem()) { ntpPending = false; Serial.println("Waktu tersinkron dari NTP"); } }
      else if (now - ntpLastMs > 3600000UL) ntpPending = true;      // sinkron ulang tiap 1 jam
      break;
    case WF_FAIL:
      if (wifiWant && wifiSsid[0] && now - wifiT0 > 60000UL) wifiStart();   // coba lagi tiap 1 menit
      break;
    default: break;
  }
}

// urutan daftar: yang tersambung dulu, lalu sinyal terkuat (per level bar), lalu nama
static bool wfBefore(const WfNet& a, const WfNet& b) {
  bool ca = wfIsCur(a.ssid), cb = wfIsCur(b.ssid);
  if (ca != cb) return ca;
  int la = wfBars(a.rssi), lb = wfBars(b.rssi);
  if (la != lb) return la > lb;
  return strcmp(a.ssid, b.ssid) < 0;
}
static void wfCollect(int n) {
  WfNet tmp[16]; int c = 0;
  for (int i = 0; i < n && c < 16; i++) {
    String sd = WiFi.SSID(i);
    if (sd.length() == 0 || sd.length() > 32) continue;       // lewati SSID tersembunyi
    int8_t r = (int8_t)WiFi.RSSI(i);
    bool dup = false;
    for (int j = 0; j < c; j++) if (!strcmp(tmp[j].ssid, sd.c_str())) { if (r > tmp[j].rssi) tmp[j].rssi = r; dup = true; break; }
    if (dup) continue;
    strncpy(tmp[c].ssid, sd.c_str(), 32); tmp[c].ssid[32] = 0;
    tmp[c].rssi = r; tmp[c].secure = (WiFi.encryptionType(i) != WIFI_AUTH_OPEN) ? 1 : 0;
    c++;
  }
  for (int i = 1; i < c; i++) {
    WfNet k = tmp[i]; int j = i - 1;
    while (j >= 0 && wfBefore(k, tmp[j])) { tmp[j + 1] = tmp[j]; j--; }
    tmp[j + 1] = k;
  }
  bool ch = (c != wfCount);
  for (int i = 0; !ch && i < c; i++)
    if (strcmp(tmp[i].ssid, wfNet[i].ssid) || tmp[i].secure != wfNet[i].secure || wfBars(tmp[i].rssi) != wfBars(wfNet[i].rssi)) ch = true;
  for (int i = 0; i < c; i++) wfNet[i] = tmp[i];
  wfCount = c;
  if (ch) dirty = true;
}
// pemindaian asinkron, dimulai ulang tiap WIFI_SCAN_MS selama layar Wi-Fi terbuka
static void wifiScanTask(uint32_t now) {
  if (screen != SC_WIFI || locked || !wifiWant || wifiSt == WF_OFF || wifiSt == WF_CONNECTING) return;
  if (wfScanRunning) {
    int n = WiFi.scanComplete();
    if (n == WIFI_SCAN_RUNNING) { if (now - wfScanT0 > 6000UL) { wifiScanAbort(); } return; }
    if (n >= 0) wfCollect(n);
    WiFi.scanDelete(); wfScanRunning = false; dirty = true;
  }
  if (now - wfScanT0 >= WIFI_SCAN_MS) {
    wfScanT0 = now;
    wfScanRunning = (WiFi.scanNetworks(true, false, false, 110) == WIFI_SCAN_RUNNING);
    dirty = true;
  }
}

static void closePanelNow() { cpOpen = false; cpDrag = false; cpAnim = 0; cpV = 0; cpMode = 0; cpPress = -1; cpHold = 0; trActive = false; lockSpring = false; }

// Tidur: layar mati, Wi-Fi & LED mati, CPU light-sleep. Sentuh layar untuk bangun (kembali ke lock screen).
static void goSleep() {
  if (ota::busy) { setToast("Tunggu proses update"); return; }
  closePanelNow();
  flashOn = false; ledWrite(0, 0, 0);
  wifiStop();
  locked = true; lockShift = 0; lockAuth = false; credReset();
  fadeBacklight(blLevel, 0, 250);
  sleeping = true;
}

// Deep sleep: hampir semua mati. Bangun dengan tombol BOOT (GPIO0) atau RESET -> espOS booting ulang.
static void enterDeepSleep() {
  if (ota::busy) { setToast("Tunggu proses update"); return; }
  waitPush();
  closePanelNow();
  flashOn = false; ledWrite(0, 0, 0);
  wifiStop();
  fadeBacklight(blLevel, 0, 250);
  tft.sendCommand(0x28);                                 // display off
  tft.sendCommand(0x10);                                 // sleep in
  delay(10);
#if defined(ESP_ARDUINO_VERSION_MAJOR) && ESP_ARDUINO_VERSION_MAJOR >= 3
  ledcDetach(PIN_TFT_BL);
#else
  ledcDetachPin(PIN_TFT_BL);
#endif
  pinMode(PIN_TFT_BL, OUTPUT); digitalWrite(PIN_TFT_BL, LOW);
  gpio_hold_en((gpio_num_t)PIN_TFT_BL);                  // jaga backlight tetap mati selama deep sleep
  gpio_deep_sleep_hold_en();
  esp_sleep_enable_ext0_wakeup((gpio_num_t)PIN_WAKE, 0);
  rtc_gpio_pullup_en((gpio_num_t)PIN_WAKE);
  rtc_gpio_pulldown_dis((gpio_num_t)PIN_WAKE);
  Serial.println("Deep sleep...");
  Serial.flush();
  esp_deep_sleep_start();
}

static void closeSheet() { sheetOpen = false; lastAnimMs = millis(); dirty = true; }
static void applyTheme(int i) {
  if (i == curTheme) return;
  curTheme = i; bgTheme = -1; prefs.putUChar("tema", (uint8_t)i); buildButtons(); dirty = true;
}
static void wake() {
  sleeping = false; dirty = true;
  if (wifiWant) wifiStart();
  if (timeSynced) syncFromSystem();
  renderFrame(); fadeBacklight(0, blLevel, 250);
}

static void leaveScreen() {
  if (screen == SC_NOTEEDIT) saveNote();
  if (screen == SC_WIFI) wifiScanAbort();
  if (screen == SC_WIFIPASS) pwWipe();                   // password tidak disimpan di RAM setelah layar ditutup
}
static void goHome() { leaveScreen(); goScreen(SC_HOME); }
static void goBack() {
  switch (screen) {
    case SC_NOTEEDIT: leaveScreen(); goScreen(SC_NOTES); break;
    case SC_FILEVIEW: goScreen(SC_FILES); break;
    case SC_WIFIPASS: leaveScreen(); goScreen(SC_WIFI); break;
    case SC_SYSINFO: case SC_LOCKSET: case SC_SETTIME: case SC_OTA: case SC_ABOUT: goScreen(SC_SETTINGS); break;
    case SC_PINPAD: case SC_PATTERN: goScreen(credPurpose == 1 ? SC_SETTINGS : SC_LOCKSET); break;
    case SC_HOME: break;
    default: goHome(); break;
  }
}
static void navAction(int i) {
  if (i == 0) { if (sheetOpen) closeSheet(); else goBack(); return; }
  if (sheetOpen) closeSheet();
  if (i == 1) {
    if (screen == SC_HOME && homePage > 0) { homePage = 0; homeSpring = true; lastAnimMs = millis(); buildButtons(); dirty = true; }
    else goHome();
  }
  else { if (screen == SC_RECENTS) goHome(); else { leaveScreen(); goScreen(SC_RECENTS); } }
}

// ---- buka layar Wi-Fi (dari tahan tile Wi-Fi), pilih jaringan, keyboard password ----
static void wifiOpenSettings() {
  cpOpen = false; cpMode = 0; lastAnimMs = millis();
  leaveScreen();
  wfPage = 0; wfScanRunning = false; wfScanT0 = millis() - WIFI_SCAN_MS;   // pindai langsung
  goScreen(SC_WIFI);
}
static void wfSelect(int idx) {
  if (idx < 0 || idx >= wfCount) return;
  strncpy(selSsid, wfNet[idx].ssid, 32); selSsid[32] = 0;
  selSecure = wfNet[idx].secure != 0;
  if (!selSecure) { wifiConnectTo(selSsid, ""); setToast("Menyambung..."); return; }   // jaringan terbuka: langsung sambung
  wifiScanAbort();
  pwWipe(); pwLastMs = 0;
  goScreen(SC_WIFIPASS);
}
static void pwBackspace() { if (pwLen > 0) { pwBuf[--pwLen] = 0; pwLastMs = 0; } }
static void pwConnect() {
  if (pwBusy()) return;
  if (selSecure && pwLen < 8) { setPwMsg("Password minimal 8 karakter", true); return; }
  pwMsg[0] = 0;
  wifiConnectTo(selSsid, pwBuf);
}
static void pwPress(int code) {
  if (pwBusy()) return;                                  // saat menyambung, keyboard dikunci
  pwMsg[0] = 0;
  switch (code) {
    case -1:                                             // Shift (ketuk 2x = Caps Lock) / halaman simbol
      if (kbL >= 3) kbL = (kbL == 3) ? 4 : 3;
      else if (kbL == 0) { kbL = 1; shiftTapMs = millis(); }
      else if (kbL == 1 && millis() - shiftTapMs < 400UL) kbL = 2;
      else kbL = 0;
      buildButtons(); return;
    case -2: pwBackspace(); return;
    case -3: kbL = (kbL >= 3) ? 0 : 3; buildButtons(); return;
    case -4: case 202: pwConnect(); return;
    case 201: pwShow = !pwShow; return;
    default: break;
  }
  if (code > 0 && code < 127 && pwLen < 63) {
    pwBuf[pwLen++] = (char)code; pwBuf[pwLen] = 0; pwLastMs = millis();
    if (kbL == 1) { kbL = 0; buildButtons(); }           // Shift sekali pakai
  }
}

static void kbPress(int code) {
  if (code == -1) { kbLayer = (kbLayer == 1) ? 0 : 1; buildButtons(); return; }
  if (code == -3) { kbLayer = (kbLayer == 2) ? 0 : 2; buildButtons(); return; }
  if (code == -2) { if (noteLen > 0) noteText[--noteLen] = 0; return; }
  if (code == -4) code = '\n';
  if (noteLen < 180) {
    noteText[noteLen++] = (char)code; noteText[noteLen] = 0;
    if (kbLayer == 1) { kbLayer = 0; buildButtons(); }
  }
}
static void adjustTime(int f, int d) {
  switch (f) {
    case 0: clk_hh = (clk_hh + d + 24) % 24; break;
    case 1: clk_mm = (clk_mm + d + 60) % 60; lastMinuteMs = millis(); break;
    case 2: clk_wd = (clk_wd + d + 7) % 7; break;
    case 3: clk_dd += d; if (clk_dd < 1) clk_dd = daysInMonth(clk_mo); if (clk_dd > daysInMonth(clk_mo)) clk_dd = 1; break;
    default: clk_mo = (clk_mo + d + 12) % 12; if (clk_dd > daysInMonth(clk_mo)) clk_dd = daysInMonth(clk_mo); break;
  }
}
static void setBrightFromX(int x) {
  int v = 10 + (x - 24) * 90 / 192; if (v < 10) v = 10; if (v > 100) v = 100;
  if (v != brightPct) { brightPct = v; applyBrightness(); dirty = true; }
}

// Tutup aplikasi: semua data kerjanya dibuang (bukan sekadar dihapus dari daftar)
static void closeApp(int a) {
  switch (a) {
    case 0: fCount = 0; fPage = 0; viewLen = 0; viewBuf[0] = 0; viewName[0] = 0; viewBinary = false; break;   // Berkas
    case 1: calcReset(); break;                                                                              // Kalkulator
    case 2: noteLen = 0; noteText[0] = 0; noteSlot = 0; kbLayer = 0; break;                                  // Catatan (sudah tersimpan di flash)
    case 3: swRunning = false; swAcc = 0; break;
    case 6: dinoReset(); break;
    case 7: pongReset(); break;
    case 8: flappyReset(); break;                                                             // Alat (stopwatch)
    default: break;
  }
}
static void closeAllApps() {
  for (int i = 0; i < 4; i++) { if (recents[i] >= 0) closeApp(recents[i]); recents[i] = -1; }
  wifiScanAbort(); wfCount = 0; wfPage = 0; pwWipe();     // sisa data layar Wi-Fi
  Serial.printf("Semua aplikasi ditutup. RAM bebas: %u KB\n", (unsigned)(ESP.getFreeHeap() / 1024));
}

static void act(int code) {
  switch (screen) {
    case SC_HOME: openApp(code); break;
    case SC_CALC: calcPress(code); dirty = true; break;
    case SC_NOTES: noteSlot = code - 1; loadNote(noteSlot); kbLayer = 0; goScreen(SC_NOTEEDIT); break;
    case SC_NOTEEDIT:
      if (code == 200) { noteLen = 0; noteText[0] = 0; } else kbPress(code);
      dirty = true; break;
    case SC_FILES:
      if (code == 90) { if (fPage > 0) fPage--; buildButtons(); }
      else if (code == 91) { if ((fPage + 1) * 4 < fCount) fPage++; buildButtons(); }
      else { int idx = fPage * 4 + (code - 10); if (idx < fCount) { openFileView(fNames[idx]); goScreen(SC_FILEVIEW); } }
      dirty = true; break;
    case SC_FILEVIEW: {
      if (code == 50) { char p[32]; snprintf(p, sizeof(p), "/%s", viewName); LittleFS.remove(p); goScreen(SC_FILES); }
      break;
    }
    case SC_STOPWATCH:
      if (code == 1) { if (swRunning) { swAcc += millis() - swStart; swRunning = false; } else { swStart = millis(); swRunning = true; } }
      else { swRunning = false; swAcc = 0; }
      buildButtons(); dirty = true; break;
    case SC_OTA:
      if (WiFi.status()!=WL_CONNECTED) setToast("Hubungkan Wi-Fi dahulu"); else ota::check();
      break;
    case SC_SETTINGS:
      if (code == 9) goScreen(SC_OTA);
      else if (code == 2) { sheetOpen = true; lastAnimMs = millis(); dirty = true; }
      else if (code == 3) goScreen(SC_SETTIME);
      else if (code == 4) { calibrate(); goScreen(SC_SETTINGS); }
      else if (code == 5) goSleep();
      else if (code == 6) goScreen(SC_ABOUT);
      else if (code == 7) {                              // kunci layar: minta PIN/pola lama dulu bila sudah aktif
        if (lkType == 0) goScreen(SC_LOCKSET);
        else { credPurpose = 1; goScreen(lkType == 1 ? SC_PINPAD : SC_PATTERN); }
      }
      else if (code == 8) goScreen(SC_SYSINFO);
      break;
    case SC_LOCKSET:
      if (code == 1) {
        if (lkType != 0) { lkType = 0; lkHash = 0; prefs.putUChar("lkT", 0); prefs.putUInt("lkH", 0); setToast("Kunci layar dimatikan"); }
        buildButtons(); dirty = true;
      } else { credPurpose = 2; goScreen(code == 2 ? SC_PINPAD : SC_PATTERN); }
      break;
    case SC_SETTIME: adjustTime(code / 2, (code & 1) ? 1 : -1); dirty = true; break;
    case SC_RECENTS:
      if (code == 99) { closeAllApps(); buildButtons(); dirty = true; }
      else if (code >= 0 && code < 4 && recents[code] >= 0) openApp(recents[code]);
      break;
    case SC_WIFI:
      if (code == 1) { wifiToggle(); dirty = true; }
      else if (code == 90) { if (wfPage > 0) wfPage--; dirty = true; }
      else if (code == 91) { if ((wfPage + 1) * 5 < wfCount) wfPage++; dirty = true; }
      else if (code >= 10 && code < 15) wfSelect(wfPage * 5 + (code - 10));
      break;
    case SC_WIFIPASS: pwPress(code); dirty = true; break;
    default: break;
  }
}

static void cpSetBright(int x) {
  int v = 10 + (x - 46) * 90 / 160; if (v < 10) v = 10; if (v > 100) v = 100;
  if (v != brightPct) { brightPct = v; applyBrightness(); dirty = true; }
}

static void cpTap(int x, int y) {                        // panel terbuka penuh (oy = 0)
  dirty = true;
  if (cpMode == 1) {                                     // pilih warna senter
    for (int k = 0; k < 8; k++) {
      int cx = 39 + (k % 4) * 54, cy = 160 + (k / 4) * 50;
      if (abs(x - cx) <= 25 && abs(y - cy) <= 24) { flashPick(k); cpMode = 0; return; }
    }
    cpMode = 0; return;
  }
  if (cpMode == 2) {                                     // konfirmasi deep sleep
    if (y >= 184 && y < 220 && x >= 126 && x < 216) { enterDeepSleep(); return; }
    cpMode = 0; return;
  }
  if (y > CP_H) { cpOpen = false; return; }              // ketuk di luar panel = tutup
  if (!locked && y < 55 && (ota::state == ota::Available || ota::state == ota::Writing)) { closePanelNow(); leaveScreen(); goScreen(SC_OTA); return; }
  switch (cpHitTile(x, y)) {
    case 0: wifiToggle(); break;
    case 1: flashToggle(); break;
    case 2: cpOpen = false; locked = true; lockShift = 0; lockAuth = false; credReset(); break;
    case 3: goSleep(); break;
    case 4: cpMode = 2; break;
    case 5: if (!locked) { cpOpen = false; leaveScreen(); goScreen(SC_SETTINGS); } break;
    default: break;
  }
}

static void onTap(int x, int y) {
  if (cpOpen) { if (cpAnim > 0.95f) cpTap(x, y); return; }
  if (locked) return;
  if (y >= NAV_Y) { navAction(x < 90 ? 0 : (x < 150 ? 1 : 2)); return; }
  if (sheetOpen) {
    if (y < SHEET_TOP_OPEN - 4) { closeSheet(); return; }
    if (x > 196 && y < SHEET_TOP_OPEN + 44) { closeSheet(); return; }
    static const int DX[3] = {50, 120, 190};
    int cy = SHEET_TOP_OPEN + 85;
    for (int i = 0; i < 3; i++) if (abs(x - DX[i]) <= 34 && y >= cy - 30 && y <= cy + 42) { applyTheme(i); return; }
    return;
  }
  int id = hitBtn(x, y);
  if (id >= 0) act(btns[id].code);
}

// ============================== KUNCI LAYAR: LOGIKA ==========================
static uint32_t credHash(uint8_t type, const char* s) {
  uint32_t h = 2166136261UL ^ (uint32_t)(ESP.getEfuseMac() & 0xFFFFFFFFULL) ^ ((uint32_t)type * 0x9E3779B1UL);
  for (const char* p = s; *p; p++) { h ^= (uint8_t)*p; h *= 16777619UL; }
  return h;
}
static void credMsgSet(const char* m, bool err) {
  strncpy(credMsg, m, sizeof(credMsg) - 1); credMsg[sizeof(credMsg) - 1] = 0;
  credMsgErr = err; credMsgT = millis(); dirty = true;
}
static void credFail(const char* m) {                  // salah: PIN bergetar, pola merah sebentar
  credShakeT = millis(); credMsgSet(m, true);
  credLen = 0; credBuf[0] = 0;
  if (credKind() == 2) { patErr = true; patErrT = millis(); }
}
static void credSubmit(const char* s) {
  int kind = credKind(), len = (int)strlen(s);
  if (len < 4) { credFail(kind == 1 ? "Minimal 4 angka" : "Hubungkan minimal 4 titik"); return; }
  uint32_t now = millis();
  if (credPurpose <= 1) {                              // verifikasi: buka kunci / sebelum mengubah
    if (now < credLockUntil) { char b[40]; snprintf(b, sizeof(b), "Coba lagi dalam %us", (unsigned)((credLockUntil - now + 999) / 1000)); credFail(b); return; }
    if (credHash((uint8_t)kind, s) == lkHash) {
      credFails = 0;
      if (credPurpose == 0) { lockAuth = false; locked = false; lockShift = 0; credReset(); dirty = true; }
      else goScreen(SC_LOCKSET);
    } else if (++credFails >= 5) { credFails = 0; credLockUntil = now + 30000UL; credFail("Terlalu banyak salah, tunggu 30 dtk"); }
    else credFail(kind == 1 ? "PIN salah" : "Pola salah");
    return;
  }
  if (credPurpose == 2) {                              // entri pertama -> minta konfirmasi
    strncpy(credTmp, s, 9); credTmp[9] = 0; credPurpose = 3;
    credReset(); credMsgSet("Ulangi untuk konfirmasi", false);
    return;
  }
  if (!strcmp(credTmp, s)) {                           // konfirmasi cocok -> simpan
    lkType = (uint8_t)kind; lkHash = credHash((uint8_t)kind, s);
    prefs.putUChar("lkT", lkType); prefs.putUInt("lkH", lkHash);
    credTmp[0] = 0; credFails = 0;
    setToast(kind == 1 ? "PIN disimpan" : "Pola disimpan");
    goScreen(SC_LOCKSET);
  } else { credPurpose = 2; credTmp[0] = 0; credFail("Tidak sama, ulangi dari awal"); }
}
static void patAdd(int n) {
  for (int i = 0; i < patLen; i++) if (patSeq[i] == n) return;
  if (patLen > 0) {                                    // garis melewati titik di tengah -> ikut terpilih
    int m = patSeq[patLen - 1], r1 = m / 3, c1 = m % 3, r2 = n / 3, c2 = n % 3;
    if (((r1 + r2) % 2 == 0) && ((c1 + c2) % 2 == 0)) {
      int mid = ((r1 + r2) / 2) * 3 + (c1 + c2) / 2; bool seen = false;
      for (int i = 0; i < patLen; i++) if (patSeq[i] == mid) seen = true;
      if (!seen && patLen < 9) patSeq[patLen++] = (uint8_t)mid;
    }
  }
  if (patLen < 9) patSeq[patLen++] = (uint8_t)n;
}
static void credDown(int x, int y) {
  lockAuthLast = millis();
  credTouch = true; credCancelDown = false; ignoreTouch = true;
  if (locked && y >= 286) { credCancelDown = true; return; }
  credMsg[0] = 0;
  if (credKind() == 1) credKey = (int8_t)pinKeyAt(x, y);
  else { patErr = false; patLen = 0; patDrag = true; patFx = (float)x; patFy = (float)y; int n = patDotAt(x, y); if (n >= 0) patAdd(n); }
  dirty = true;
}
static void credMove(int x, int y) {
  lockAuthLast = millis();
  if (credCancelDown) return;
  if (credKind() == 1) { if (credKey >= 0 && pinKeyAt(x, y) != credKey) credKey = -1; }
  else if (patDrag) { patFx = (float)x; patFy = (float)y; int n = patDotAt(x, y); if (n >= 0) patAdd(n); dirty = true; }
}
static void credUp() {
  credTouch = false; lockAuthLast = millis();
  if (credCancelDown) { credCancelDown = false; if (locked) { lockAuth = false; credReset(); } dirty = true; return; }
  if (credKind() == 1) {
    int k = credKey; credKey = -1;
    if (k < 0) return;
    if (k == 9) { if (credLen) credBuf[--credLen] = 0; }
    else if (k == 11) credSubmit(credBuf);
    else if (credLen < 8) { credBuf[credLen++] = (char)(k == 10 ? '0' : '1' + k); credBuf[credLen] = 0; credPopT = millis(); }
  } else {
    patDrag = false;
    if (patLen == 0) return;
    char s[10]; for (int i = 0; i < patLen; i++) s[i] = (char)('0' + patSeq[i]);
    s[patLen] = 0;
    credSubmit(s);
  }
  dirty = true;
}

static float cpRubber(float r) {                         // tarikan melewati batas terasa "kenyal"
  if (r < 0) return 0;
  if (r > 1) return 1.0f + 0.06f * tanhf((r - 1.0f) * 3.0f);
  return r;
}
static inline bool uiBusy() { return trActive || (lockSpring && lockTarget > 100.0f); }

static void pollTouch() {
  int sx, sy;
  bool pr = tsRead(sx, sy);
  if (pr) {
    tMiss = 0;
    if (sleeping) {
      if (++tPend >= (SLEEP_LIGHT ? 1 : 2)) { tPend = 0; wake(); ignoreTouch = true; tDown = true; tBlocked = false; t0x = tx = sx; t0y = ty = sy; }
      return;
    }
    if (!tDown) {
      if (++tPend < (isGameScreen(screen) ? 1 : 2)) return;   // butuh 2 pembacaan berurutan (anti-noise); game: 1 agar responsif
      tPend = 0; tDown = true; ignoreTouch = false; bsNext = 0;
      t0x = tx = sx; t0y = ty = sy; tT0 = millis();
      fxs = (float)sx; fys = (float)sy; tvy = 0; tvx = 0; tLastMs = tT0; tLastY = fys; tLastX = fxs;
      tBlocked = uiBusy();                          // sedang transisi / membuka kunci: sentuhan diabaikan
      if (tBlocked) return;
      pressedId = -1; pressedNav = -1; cpPress = -1; cpHold = 0;
      cpSlide = false; cpDrag = false; homeDrag = false; cpLongDone = false; lockDrag = false; lockShift = 0; swipeTop = false; credTouch = false;
      lockSpring = false; lockSnapOK = false;
      if (cpOpen) {
        if (cpAnim > 0.9f && cpMode == 0) {
          if (sy >= 54 && sy < 96) { cpSlide = true; cpSetBright(sx); }      // slider kecerahan
          else cpPress = cpHitTile(sx, sy);
        }
      } else if (!sheetOpen) {
        swipeTop = (sy < 34);                       // mulai dari tepi atas = tarik control panel
        if (locked) { if (lockAuth) { lockDrag = false; if (!swipeTop) credDown(sx, sy); } else lockDrag = !swipeTop; }   // lock screen: geser ke atas / PIN / pola
        else {
          if (sy >= NAV_Y) pressedNav = sx < 90 ? 0 : (sx < 150 ? 1 : 2); else pressedId = (screen == SC_HOME && !homeSettled()) ? -1 : hitBtn(sx, sy);
          if (credScreen() && !swipeTop && sy < NAV_Y) credDown(sx, sy);
          if (pressedId >= 0 && btns[pressedId].style != B_APP) { rip.on = true; rip.bi = pressedId; rip.x = (float)sx; rip.y = (float)sy; rip.t0 = millis(); }
        }
      }
      dirty = true;
    } else {
      if (tBlocked) return;
      fxs += (sx - fxs) * 0.6f; fys += (sy - fys) * 0.6f;      // saring getaran sentuhan
      tx = (int)(fxs + 0.5f); ty = (int)(fys + 0.5f);
      uint32_t nm = millis();
      if (nm > tLastMs) { float inst = (fys - tLastY) * 1000.0f / (float)(nm - tLastMs); tvy = tvy * 0.6f + inst * 0.4f; float ix = (fxs - tLastX) * 1000.0f / (float)(nm - tLastMs); tvx = tvx * 0.6f + ix * 0.4f; tLastMs = nm; tLastY = fys; tLastX = fxs; }
      int dx = tx - t0x, dy = ty - t0y;
      if (cpSlide) cpSetBright(tx);
      else if (cpDrag) {                            // panel mengikuti jari (kenyal di batas)
        cpAnim = cpRubber(cpDragP0 + (ty - cpDragY0) / (CP_H * 0.8f)); cpV = 0;
        dirty = true;
      } else if (!sheetOpen) {
        if (homeDrag) { homePos = homeRubber(homeDragP0 - (float)dx); dirty = true; }
        else if (screen == SC_HOME && !cpOpen && !cpDrag && !locked && !swipeTop && abs(dx) > 14 && abs(dx) > abs(dy)) {
          homeDrag = true; homeSpring = false; homeV = 0; homeDragP0 = homePos; pressedId = pressedNav = -1; rip.on = false; dirty = true;   // geser halaman beranda
        }
        else if (!cpOpen && swipeTop && dy > 12 && dy > abs(dx)) { cpDrag = true; cpMode = 0; pressedId = pressedNav = -1; lockDrag = false; lockShift = 0; cpDragP0 = cpAnim; cpDragY0 = ty; }
        else if (cpOpen && cpMode == 0 && dy < -12 && -dy > abs(dx)) { cpDrag = true; cpPress = -1; cpHold = 0; cpDragP0 = cpAnim; cpDragY0 = ty; }
        else if (lockDrag && !cpOpen) {
          int s = -dy; if (s < 0) s = 0; if (s > 240) s = 240;
          if (s > 0 && !lockSnapOK && snapBuf2 && lkType == 0) {   // siapkan layar di balik kunci (dirender sekali)
            locked = false; u16* keep = fb; fb = snapBuf2; drawScene(); fb = keep; locked = true; lockSnapOK = true;
          }
          if (s != lockShift) { lockShift = s; dirty = true; }
        }
      }
      if (credTouch && !cpDrag) credMove(tx, ty);
      if ((abs(dx) > 16 || abs(dy) > 16) && (pressedId >= 0 || pressedNav >= 0 || cpPress >= 0)) { pressedId = pressedNav = -1; cpPress = -1; cpHold = 0; dirty = true; }
      // tahan tile di control panel: Senter -> pilih warna LED, Wi-Fi -> Pengaturan Wi-Fi
      if (cpOpen && (cpPress == 0 || cpPress == 1) && !cpLongDone && abs(dx) < 14 && abs(dy) < 14) {
        uint32_t el = millis() - tT0;
        cpHold = el > 120 ? (float)(el - 120) / (float)(LONG_PRESS_MS - 120) : 0.0f;
        if (cpHold > 1) cpHold = 1;
        dirty = true;
        if (el >= LONG_PRESS_MS) {
          cpLongDone = true; ignoreTouch = true; cpHold = 0;
          int tile = cpPress; cpPress = -1; cpSv[tile] = -9.0f;      // "klik": tile memantul
          if (tile == 1) cpMode = 1;
          else if (!locked) wifiOpenSettings();
        }
      }
      // tahan tombol hapus di keyboard password = hapus berulang
      if (screen == SC_WIFIPASS && !cpOpen && !locked && pressedId >= 0 && pressedId < nbtn && btns[pressedId].code == -2) {
        uint32_t nowMs = millis();
        if (nowMs - tT0 >= 450UL && nowMs >= bsNext) { bsNext = nowMs + 60UL; ignoreTouch = true; if (!pwBusy()) pwBackspace(); dirty = true; }
      }
    }
  } else {
    tPend = 0;
    if (tDown) {
      if (tMiss == 0) tMissT0 = millis();
      tMiss++;
      if (tMiss >= 2 && (isGameScreen(screen) || millis() - tMissT0 >= 40)) {          // lepas jari (>= 2 bacaan kosong & >= 40 ms)
        tDown = false; tMiss = 0;
        bool blocked = tBlocked; tBlocked = false;
        pressedId = -1; pressedNav = -1; cpPress = -1; cpHold = 0;
        if (!blocked) {
          bool wasSlide = cpSlide; cpSlide = false;
          if (wasSlide) prefs.putUChar("bri", (uint8_t)brightPct);
          if (homeDrag) {                                     // lepas: pilih halaman terdekat / sesuai lemparan
            homeDrag = false;
            int pg = (int)floorf(homePos / (float)SCR_W + 0.5f);
            if (tvx < -420.0f) pg = homePage + 1; else if (tvx > 420.0f) pg = homePage - 1;
            if (pg < 0) pg = 0; if (pg > HOME_PAGES - 1) pg = HOME_PAGES - 1;
            homePage = pg; homeSpring = true; homeV = -tvx * 0.5f; lastAnimMs = millis();
            buildButtons();
          } else if (cpDrag) {
            cpDrag = false;
            bool open;
            if (tvy > 650.0f) open = true;                  // lemparan cepat ke bawah / atas menentukan arah
            else if (tvy < -650.0f) open = false;
            else open = cpAnim > (cpOpen ? 0.6f : 0.35f);
            cpOpen = open;
            cpV = tvy / (CP_H * 0.8f) * 0.6f;               // lanjutkan momentum jari ke pegas
            if (cpV > 6) cpV = 6; if (cpV < -6) cpV = -6;
            if (!cpOpen) cpMode = 0;
            lastAnimMs = millis();
          } else if (lockDrag && lockShift > 0) {
            bool unlock = lockShift > 70 || tvy < -600.0f;
            lockSpring = true; lockPos = (float)lockShift; lockVel = -tvy * 0.6f; lockTarget = unlock ? 250.0f : 0.0f;
            lastAnimMs = millis();
          } else if (credTouch) {
            credUp();
          } else if (!ignoreTouch) {
            int dx = abs(tx - t0x), dy = ty - t0y;
            if (sheetOpen && t0y >= SHEET_TOP_OPEN && dy > 36) closeSheet();
            else if (dx < 18 && abs(dy) < 18 && millis() - tT0 < 900) onTap(t0x, t0y);
          }
          lockDrag = false; if (!lockSpring) lockShift = 0; swipeTop = false;
        }
        dirty = true;
      }
    }
  }
}

// gerakkan semua pegas efek sentuhan; true = masih ada yang bergerak
static bool updateSprings(float dt) {
  bool moving = false;
  const float K = 520.0f, C = 26.0f;
  for (int i = 0; i < nbtn; i++) {
    float tg = (i == pressedId) ? 1.0f : 0.0f;
    if (bpX[i] != tg || bpV[i] != 0) {
      springStep(bpX[i], bpV[i], tg, dt, K, C);
      if (fabsf(bpX[i] - tg) < 0.004f && fabsf(bpV[i]) < 0.05f) { bpX[i] = tg; bpV[i] = 0; } else moving = true;
    }
  }
  for (int i = 0; i < 3; i++) {
    float tg = (i == pressedNav) ? 1.0f : 0.0f;
    if (navSp[i] != tg || navSv[i] != 0) {
      springStep(navSp[i], navSv[i], tg, dt, K, C);
      if (fabsf(navSp[i] - tg) < 0.004f && fabsf(navSv[i]) < 0.05f) { navSp[i] = tg; navSv[i] = 0; } else moving = true;
    }
  }
  for (int i = 0; i < 6; i++) {
    float tg = (i == cpPress) ? 1.0f : 0.0f;
    if (cpSx[i] != tg || cpSv[i] != 0) {
      springStep(cpSx[i], cpSv[i], tg, dt, K, C);
      if (fabsf(cpSx[i] - tg) < 0.004f && fabsf(cpSv[i]) < 0.05f) { cpSx[i] = tg; cpSv[i] = 0; } else moving = true;
    }
  }
  {
    float tg = (tDown && !tBlocked && swipeTop && !cpDrag && !cpOpen) ? 1.0f : 0.0f;
    if (topHintX != tg || topHintV != 0) {
      springStep(topHintX, topHintV, tg, dt, 380.0f, 28.0f);
      if (fabsf(topHintX - tg) < 0.004f && fabsf(topHintV) < 0.05f) { topHintX = tg; topHintV = 0; } else moving = true;
    }
  }
  for (int k = 0; k < 12; k++) {
    float tg = (credKey == k && credTouch) ? 1.0f : 0.0f;
    if (credSp[k] != tg || credSv[k] != 0) {
      springStep(credSp[k], credSv[k], tg, dt, K, C);
      if (fabsf(credSp[k] - tg) < 0.004f && fabsf(credSv[k]) < 0.05f) { credSp[k] = tg; credSv[k] = 0; } else moving = true;
    }
  }
  {
    uint32_t nw = millis();
    if (credShakeT && nw - credShakeT < 460) moving = true;
    if (credPopT && nw - credPopT < 170) moving = true;
    if (patErr && nw - patErrT > 650) { patLen = 0; patErr = false; moving = true; }
    if (credMsg[0] && nw - credMsgT > 3500) { credMsg[0] = 0; moving = true; }
    if (credMsg[0] && credMsgErr && nw - credMsgT < 650) moving = true;
  }
  if (rip.on) { if (millis() - rip.t0 > 430) rip.on = false; else moving = true; }
  return moving;
}

// ============================== SETUP & LOOP =================================
void setup() {
  Serial.begin(115200);
  delay(100);

  // ── Inisialisasi PSRAM paling awal ──────────────────────────────────────────
  // Wajib: Arduino IDE → Tools → PSRAM → "OPI PSRAM"
  psramManagerInit();
  // ────────────────────────────────────────────────────────────────────────────

  gpio_hold_dis((gpio_num_t)PIN_TFT_BL); gpio_deep_sleep_hold_dis();   // lepas hold setelah deep sleep
  ledWrite(0, 0, 0);                                                     // pastikan LED senter padam
  pinMode(PIN_TS_CS, OUTPUT);  digitalWrite(PIN_TS_CS, HIGH);
  pinMode(PIN_TFT_CS, OUTPUT); digitalWrite(PIN_TFT_CS, HIGH);
#if defined(ESP_ARDUINO_VERSION_MAJOR) && ESP_ARDUINO_VERSION_MAJOR >= 3
  ledcAttach(PIN_TFT_BL, 5000, 8);
#else
  ledcSetup(0, 5000, 8); ledcAttachPin(PIN_TFT_BL, 0);
#endif
  setBacklight(0);

  tftSPI.begin(PIN_TFT_SCK, PIN_TFT_MISO, PIN_TFT_MOSI, -1);
  tft.begin(TFT_SPI_HZ);
  tft.setRotation(TFT_ROTATION);
  if (TFT_INVERT) tft.invertDisplay(true);
  tft.fillScreen(0x0000);

  if (!initAssets()) { Serial.println("Gagal memuat font/ikon"); setBacklight(255); tft.fillScreen(ILI9341_RED); while (true) delay(1000); }
  fb = allocFrame(true);
  if (!fb) { if (ota::pending()) esp_ota_mark_app_invalid_rollback_and_reboot(); Serial.println("Gagal alokasi framebuffer"); setBacklight(255); tft.fillScreen(ILI9341_RED); while (true) delay(1000); }
  bgBuf = allocFrame(false);
  snapBuf = allocFrame(false);
  snapBuf2 = allocFrame(false);
  fbAlt = allocFrame(false);
  startPushTask();
  fsOK = LittleFS.begin(!ota::pending());
  Serial.printf("RAM internal bebas : %u KB (blok terbesar %u KB)\n",
    (unsigned)(ESP.getFreeHeap() / 1024),
    (unsigned)(heap_caps_get_largest_free_block(MALLOC_CAP_INTERNAL | MALLOC_CAP_8BIT) / 1024));
  psramPrintStats();
  Serial.printf("bgCache:%s  crossfade:%s  flash-fs:%s  transisi:%s  pipeline:%s\n",
    bgBuf ? "ya" : "tidak", snapBuf ? "ya" : "tidak", fsOK ? "ya" : "tidak",
    trReady() ? "ya" : "tidak", pushTaskH ? "ya" : "tidak");

  APPS[0] = {"Berkas",     H(0x2A2616), H(0x4A4228), H(0xF4C24E), &IC_FOLDER, &IC_FOLDER_BIG};
  APPS[1] = {"Kalkulator", H(0x32200F), H(0x5A3E1E), H(0xFFA94D), &IC_CALC,   &IC_CALC_BIG};
  APPS[2] = {"Catatan",    H(0x16263A), H(0x2D4966), H(0x8CC8FF), &IC_NOTES,  &IC_NOTES_BIG};
  APPS[3] = {"Stopwatch",  H(0x143A33), H(0x2A5C51), H(0x4EE3B5), &IC_TOOLS,  &IC_TOOLS_BIG};
  APPS[4] = {"Tema",       H(0x1E2036), H(0x373C66), H(0xA8A4FF), &IC_THEME,  &IC_THEME_BIG};
  APPS[5] = {"Setelan",    H(0x1E232B), H(0x3A424E), H(0xD6DBE3), &IC_GEAR,   &IC_GEAR_BIG};
  APPS[6] = {"Dino",       H(0x24272C), H(0x474D56), H(0xE8EAED), &IC_G_DINO, &IC_G_DINO};
  APPS[7] = {"Ping Pong",  H(0x14301F), H(0x2A5C3E), H(0x6EF0A0), &IC_G_PONG, &IC_G_PONG};
  APPS[8] = {"Flappy",     H(0x33290F), H(0x66521E), H(0xFFD43B), &IC_G_FLAP, &IC_G_FLAP};

  prefs.begin("espos", false);
  gamesLoad();                                           // skor terbaik game
  curTheme = prefs.getUChar("tema", 0); if (curTheme > 2) curTheme = 0;
  brightPct = prefs.getUChar("bri", 100); if (brightPct < 10 || brightPct > 100) brightPct = 100;
  lkType = prefs.getUChar("lkT", 0); lkHash = prefs.getUInt("lkH", 0); if (lkType > 2) lkType = 0;
  blLevel = 25 + (230 * brightPct) / 100;
  wifiWant = prefs.getUChar("wifi", 1) != 0;
  {                                                       // jaringan Wi-Fi tersimpan (default: define WIFI_SSID / WIFI_PASS)
    String ws = prefs.getString("wssid", WIFI_SSID), wp = prefs.getString("wpass", WIFI_PASS);
    strncpy(wifiSsid, ws.c_str(), 32); wifiSsid[32] = 0;
    strncpy(wifiPass, wp.c_str(), 63); wifiPass[63] = 0;
  }
  if (prefs.getUChar("cok", 0)) {
    calX0 = prefs.getInt("cx0", calX0); calX1 = prefs.getInt("cx1", calX1);
    calY0 = prefs.getInt("cy0", calY0); calY1 = prefs.getInt("cy1", calY1);
    calSwap = prefs.getUChar("csw", 0); calOK = true;
  }

  screen = SC_HOME; locked = true; buildButtons();
  if (wifiWant) wifiStart();                     // Wi-Fi menyambung sambil animasi boot
  bootSequence();
  if (ota::pending()) {
    if (!fsOK || esp_ota_mark_app_valid_cancel_rollback()!=ESP_OK) esp_ota_mark_app_invalid_rollback_and_reboot();
  }
  if (!calOK) calibrate();                       // pertama kali: kalibrasi touch otomatis
  lastMinuteMs = millis(); lastAnimMs = millis();
  dirty = true;
}

void loop() {
  uint32_t now = millis();
  if (sleeping) {
    waitPush();
    pollTouch();
    if (sleeping) {
#if SLEEP_LIGHT
      esp_sleep_enable_timer_wakeup(150000ULL);    // bangun tiap 150 ms untuk cek sentuhan
      esp_light_sleep_start();
#else
      delay(20);
#endif
    }
    return;
  }
  if (tickClock(now)) dirty = true;
  wifiTask(now);
  ota::tick();
  static ota::State prev=ota::Idle;
  auto status=ota::state.load();
  if (prev!=status) { prev=status; if (screen==SC_OTA) buildButtons(); dirty=true; }
  wifiScanTask(now);

  float dt = (now - lastAnimMs) / 1000.0f;
  if (dt > 0.05f) dt = 0.05f;
  lastAnimMs = now;

  // sheet tema: pegas
  {
    float target = sheetOpen ? 1.0f : 0.0f;
    if (sheetAnim != target || sheetV != 0) {
      springStep(sheetAnim, sheetV, target, dt, 300.0f, 26.0f);
      if (!sheetOpen && sheetAnim < 0) { sheetAnim = 0; sheetV = 0; }
      if (fabsf(sheetAnim - target) < 0.002f && fabsf(sheetV) < 0.02f) { sheetAnim = target; sheetV = 0; }
      dirty = true;
    }
  }
  // control panel: pegas (meneruskan kecepatan lemparan jari)
  if (!cpDrag) {
    float ct = cpOpen ? 1.0f : 0.0f;
    if (cpAnim != ct || cpV != 0) {
      springStep(cpAnim, cpV, ct, dt, 260.0f, 23.0f);
      if (cpAnim < 0 && !cpOpen) { cpAnim = 0; cpV = 0; }
      if (fabsf(cpAnim - ct) < 0.002f && fabsf(cpV) < 0.02f) { cpAnim = ct; cpV = 0; }
      if (cpAnim == 0) cpMode = 0;
      dirty = true;
    }
  }
  // lock screen: lanjutkan geser sampai terbuka, atau kembali jika dibatalkan
  if (lockSpring) {
    springStep(lockPos, lockVel, lockTarget, dt, 240.0f, 27.0f);
    if (lockPos < 0) { lockPos = 0; lockVel = 0; }
    lockShift = (int)lockPos;
    if (lockTarget > 100.0f && lockPos >= 238.0f) {
      lockShift = 0; lockSpring = false; lockSnapOK = false;
      if (lkType != 0) { lockAuth = true; lockAuthT = now; lockAuthLast = now; credPurpose = 0; credReset(); }   // minta PIN / pola
      else locked = false;
    }
    else if (lockTarget < 1.0f && lockPos < 0.6f && fabsf(lockVel) < 4.0f) { lockShift = 0; lockSpring = false; lockSnapOK = false; }
    dirty = true;
  }
  if (locked && lockAuth) {
    if (now - lockAuthLast > 25000UL) { lockAuth = false; credReset(); dirty = true; }     // tak ada sentuhan: kembali ke lock screen
    else if (now - lockAuthT < 260) dirty = true;
  }
  if (homeSpring && !homeDrag) {                         // beranda: pegas ke halaman tujuan
    float tg = (float)(homePage * SCR_W);
    springStep(homePos, homeV, tg, dt, 320.0f, 28.0f); dirty = true;
    if (fabsf(homePos - tg) < 0.4f && fabsf(homeV) < 8.0f) { homePos = tg; homeV = 0; homeSpring = false; }
  }
  if (updateSprings(dt)) dirty = true;
  if (isGameScreen(screen) && !locked && !trActive && !cpOpen && cpAnim < 0.01f && !sheetOpen) { gameStep(now); dirty = true; }   // game: jalan tiap frame
  if (screen == SC_STOPWATCH && swRunning) dirty = true;
  if (locked && !lockDrag && !lockSpring && !lockAuth) { static uint32_t ll = 0; if (now - ll > 50) { ll = now; dirty = true; } }   // petunjuk geser bergerak
  if (screen == SC_NOTEEDIT) { static uint32_t lb = 0; if (now - lb > 450) { lb = now; dirty = true; } }
  if (screen == SC_WIFIPASS) { static uint32_t lw = 0; if (now - lw > 250) { lw = now; dirty = true; } }   // kursor berkedip
  if (screen == SC_WIFI)     { static uint32_t lq = 0; if (now - lq > 500) { lq = now; dirty = true; } }   // toast / indikator pindai
  if (screen == SC_SYSINFO)  { static uint32_t ls = 0; if (now - ls > 1000) { ls = now; dirty = true; } }

  // 1) gambar frame (tumpang-tindih dengan pengiriman frame sebelumnya)
  bool rendered = false;
  if (trActive) { if (!trFrame(now)) { trActive = false; dirty = true; } rendered = true; }
  else if (dirty) { dirty = false; drawScene(); rendered = true; }

  // 2) baca sentuhan saat SPI bebas, 3) kirim frame di latar belakang
  waitPush();
  pollTouch();
  if (rendered) presentFrame(); else delay(4);
}
